# Keil uVision project helloworld.uvprojx, settings and files
target AWS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: helloworld +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: makeimg.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: WM_W600,AMAZON_FREERTOS_ENABLE_UNIT_TESTS,UNITY_INCLUDE_CONFIG_H
  c misc: --c99 --gnu
  c include: ..\common\config_files;..\..\..\..\lib\include;..\..\..\..\lib\third_party\jsmn;..\..\..\..\lib\third_party\mbedtls\include;..\..\..\..\lib\include\private;..\..\..\..\lib\FreeRTOS\portable\RVDS\ARM_CM3;..\..\..\common\include;..\..\..\..\lib\third_party\pkcs11;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Platform\Inc;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\OS;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Platform\Boot\armcc;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\WiFi;..\common\config_files;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\Driver;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\Platform;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\OS;..\..\..\common\include;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Platform\Common\crypto\digest;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Platform\Common\crypto\math;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Platform\Common\crypto\symmetric;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\App\matrixssl\core;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Platform\Common\crypto;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\App;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\Net;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\Driver;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\Platform;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\WiFi;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\App\matrixssl;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Platform\Common\Params;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\Network\lwip2.0.3\include;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\App\ping;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\App\iperf;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\App\dhcpserver;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\App\dnsserver;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\Network\api;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Include\Net;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\Network\lwip2.0.3\include;..\..\..\..\lib\third_party\mcu_vendor\wm\w60x\Src\Network\lwip2.0.3\include\lwip;..\..\..\common\include;E:\WM2019_02\Amazon_FreeRTOS\lib\third_party\unity\src;..\..\..\..\lib\third_party\unity\extras\fixture\src;..\..\..\common\ota;..\..\..\common\include;..\..\..\..\lib\FreeRTOS-Plus-TCP\include;E:\github\amazon-freertos\lib\FreeRTOS-Plus-TCP\source\portable\Compiler\MSVC;..\..\..\..\CmBacktrace\demos\os\freertos\stm32f10x\components\cm_backtrace;..\..\..\..\CmBacktrace\cm_backtrace;..\..\..\..\SystemView\SEGGER;..\..\..\..\SystemView\Sample\FreeRTOSV10;..\..\..\..\SystemView\Config;..\..\..\..\lib\third_party\unity\src
  library: MicroLIB
  memory RVCT4: ROM 0x8010100 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group application
    ../common/application_code/: main.c
  group lib/aws/bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib/aws/crypto
    ../common/application_code/wm_code/: aws_crypto_port.c
  group lib/aws/FreeRTOS
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../lib/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_4.c
  group lib/aws/greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib/aws/mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib/aws/pkcs11
    ../../../../lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../lib/pkcs11/portable/wm/w60x/: aws_pkcs11_pal.c
  group lib/aws/secure_sockets
    ../../../../lib/secure_sockets/portable/wm/w60x/: aws_secure_sockets.c
  group lib/aws/shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib/aws/tls
    ../../../../lib/tls/: aws_tls.c
  group lib/aws/utils
    ../../../../lib/utils/: aws_system_init.c
  group lib/aws/wifi
    ../../../../lib/wifi/portable/wm/w60x/: aws_wifi.c
  group lib/third_party/jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c
  group lib/third_party/mbedtls
    ../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group lib/third_party/mcu_venor
    ../../../../lib/third_party/mcu_vendor/wm/w60x/Platform/Boot/armcc/: startup_venus.s
    ../../../../lib/third_party/mcu_vendor/wm/w60x/Src/OS/RTOS/: wm_osal_rtos.c
    ../../../../lib/third_party/mcu_vendor/wm/w60x/Lib/mdk/: libairkiss_log.lib wmdhcpserver.lib wmdnsserver.lib wmoneshot.lib wmweb.lib wmwlan.lib wmcommon.lib wmlwip.lib wmtask.lib wmdma.lib wmuart.lib wmhspi.lib wmcmd.lib wmping.lib wmdriver.lib wmmain.lib
  group lib/third_party/unity
    ../../../../lib/third_party/unity/src/: unity.c
    ../../../../lib/third_party/unity/extras/fixture/src/: unity_fixture.c
  group application/common
    ../../../../demos/common/logging/: aws_logging_task_dynamic_buffers.c
    ../../../../demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group tests/common
    ../../../common/wifi/: aws_test_wifi.c
    ../../../common/tls/: aws_test_tls.c
    ../../../common/test_runner/: aws_test_runner.c
    ../../../common/framework/: aws_test_framework.c
    ../../../common/mqtt/: aws_test_mqtt_agent.c aws_test_mqtt_lib.c
    ../../../common/secure_sockets/: aws_test_tcp.c
software components: CMSIS:CORE 5.1.2
