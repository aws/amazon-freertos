# Keil uVision project aws_tests_wifi.uvproj, settings and files
target aws_tests (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: aws_tests +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MBEDTLS_USER_CONFIG_FILE=\"mbedtls_user_config.h\" UNITY_INCLUDE_CONFIG_H RVDS_ARMCM4_NUC4xx __LITTLE_ENDIAN__ AMAZON_FREERTOS_ENABLE_UNIT_TESTS M487
  c misc: --diag_suppress=550,177,C4017,111,2770,223
  c include: ..\..\..\..\lib\include;..\..\..\..\lib\include\private;..\..\..\..\lib\include\FreeRTOS_POSIX;..\..\..\..\lib\third_party\mcu_vendor\nuvoton\numaker_iot_m487_wifi\Device\Nuvoton\numaker_iot_m487_wifi\Include;..\..\..\..\lib\third_party\mcu_vendor\nuvoton\numaker_iot_m487_wifi\StdDriver\inc;..\..\..\..\lib\third_party\mcu_vendor\nuvoton\numaker_iot_m487_wifi\middleware\wifi_esp8266;..\..\..\..\tests\common\include;..\..\..\..\lib\FreeRTOS\portable\RVDS\ARM_CM4F;..\;..\..\..\..\lib\FreeRTOS-Plus-TCP\include;..\..\..\..\lib\FreeRTOS-Plus-TCP\source\protocols\include;..\..\..\..\lib\FreeRTOS-Plus-TCP\source\portable\NetworkInterface\M487;..\..\..\..\lib\FreeRTOS-Plus-TCP\source\portable\Compiler\Keil;..\..\..\..\lib\third_party\mcu_vendor\nuvoton\numaker_iot_m487_wifi\CMSIS\Include;..\common\config_files;..\..\..\..\lib\third_party\mbedtls\include;..\..\..\..\lib\third_party\mbedtls\\library;..\..\..\common\include;..\..\..\..\lib\third_party\jsmn;..\..\..\..\lib\third_party\unity\src;..\..\..\..\lib\third_party\unity\extras\fixture\src;..\..\..\..\lib\third_party\pkcs11;..\..\..\..\lib\FreeRTOS-Plus-POSIX\include;..\..\..\..\lib\FreeRTOS-Plus-POSIX\include\portable\nuvoton\numaker_iot_m487_wifi;..\common\application_code\nuvoton_code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group CMSIS
    ../../../../lib/third_party/mcu_vendor/nuvoton/numaker_iot_m487_wifi/Device/Nuvoton/numaker_iot_m487_wifi/Source/: system_M480.c
    ../../../../lib/third_party/mcu_vendor/nuvoton/numaker_iot_m487_wifi/Device/Nuvoton/numaker_iot_m487_wifi/Source/ARM/: startup_M480.s
  group User
    ../common/application_code/nuvoton_code/: entropy_hardware_poll.c
    ../common/application_code/: main.c
  group FreeRTOS
    ../../../../lib/FreeRTOS/: list.c queue.c tasks.c timers.c event_groups.c stream_buffer.c
    ../../../../lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_2.c heap_4.c
  group NVT-Library
    ../../../../lib/third_party/mcu_vendor/nuvoton/numaker_iot_m487_wifi/StdDriver/src/: clk.c retarget.c sys.c uart.c crypto.c fmc.c gpio.c
  group tests
    ../../../../demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
    ../../../common/crypto/: aws_test_crypto.c
    ../../../common/framework/: aws_test_framework.c
    ../../../common/greengrass/: aws_test_greengrass_discovery.c aws_test_helper_secure_connect.c
    ../../../../demos/common/logging/: aws_logging_task_dynamic_buffers.c
    ../../../common/memory_leak/: aws_memory_leak.c
    ../../../common/mqtt/: aws_test_mqtt_agent.c aws_test_mqtt_lib.c
    ../../../common/pkcs11/: aws_test_pkcs11.c
    ../../../common/posix/: aws_test_posix_clock.c aws_test_posix_mqueue.c aws_test_posix_pthread.c aws_test_posix_semaphore.c aws_test_posix_stress.c aws_test_posix_timer.c aws_test_posix_utils.c
    ../../../common/secure_sockets/: aws_test_tcp.c
    ../../../common/shadow/: aws_test_shadow.c
    ../../../common/test_runner/: aws_test_runner.c
    ../../../common/tls/: aws_test_tls.c
    ../../../common/wifi/: aws_test_wifi.c
  group FreeRTOS-Plus-TCP
    ../../../../lib/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/M487/: m480_eth.c NetworkInterface.c
    ../../../../lib/FreeRTOS-Plus-TCP/source/portable/BufferManagement/: BufferAllocation_1.c
    ../../../../lib/FreeRTOS-Plus-TCP/source/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
  group lib-utils
    ../../../../lib/utils/: aws_system_init.c
  group lib-bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib-secure-sockets-plus-tcp
    ../../../../lib/secure_sockets/portable/freertos_plus_tcp/: aws_secure_sockets.c
  group lib-mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib-crypto
    ../../../../lib/crypto/: aws_crypto.c
  group lib-pkcs11
    ../../../../lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../lib/pkcs11/portable/nuvoton/numaker_iot_m487_wifi/: aws_pkcs11_pal.c
  group 3rd-mbedtls
    ../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group lib-tls
    ../../../../lib/tls/: aws_tls.c
  group lib-greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib-shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib-wifi
    ../../../../lib/wifi/portable/nuvoton/numaker_iot_m487_wifi/: aws_wifi.c
    ../../../../lib/secure_sockets/portable/nuvoton/numaker_iot_m487_wifi/: aws_secure_sockets.c
    ../../../../lib/third_party/mcu_vendor/nuvoton/numaker_iot_m487_wifi/middleware/wifi_esp8266/: esp8266_wifi.c
  group 3rd-unity
    ../../../../lib/third_party/unity/src/: unity.c
    ../../../../lib/third_party/unity/extras/fixture/src/: unity_fixture.c
  group FreeRTOS-Plus-POSIX
    ../../../../lib/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group 3rd-jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c
