# IAR project aws_tests.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54018 NXP LPC54018
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; XIP_IMAGE; CPU_LPC54018; SDK_DEBUGCONSOLE=1; USB_STACK_FREERTOS; USB_STACK_USE_DEDICATED_RAM=1; CPU_LPC54018JET180=1; USE_RTOS=1; FSL_RTOS_FREE_RTOS; A_LITTLE_ENDIAN; AMAZON_FREERTOS_ENABLE_UNIT_TESTS; UNITY_INCLUDE_CONFIG_H
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../common/application_code/nxp_code; ../common/config_files; ../../../common/include; ../../../common/secure_sockets/portable/nxp/lpc54018iotmodule; ../../../../lib/third_party/unity/src; ../../../../lib/third_party/unity/extras/fixture/src; ../../../../lib/third_party/mcu_vendor/nxp/LPC54018; ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/drivers; ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/drivers/common; ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities; ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/debug_console; ..\..\..\..\lib\third_party\mbedtls\include; ..\..\..\..\lib\include; ..\..\..\..\lib\include\private; ..\..\..\..\lib\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\..\..\lib\third_party\jsmn; ..\..\..\..\lib\third_party\pkcs11; ..\..\..\..\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\utilities\log; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\utilities\io; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\utilities\str; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos\gt202; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/port/env/freertos; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/include; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/include/AR6002; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/include/AR6002/hw2.0/hw; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/include/AR6002/hw4.0/hw; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/custom_src/stack_custom; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/custom_src/include; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/common_src/include; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/common_src/stack_common; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/common_src/hcd; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/common_src/wmi; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/port; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/wifi_qca/port/drivers/flexcomm_freertos; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/usb/device; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/usb/include; ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\middleware/usb/osa; ..\..\..\..\lib\FreeRTOS-Plus-POSIX\include\portable\nxp\lpc54018iotmodule
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; XIP_IMAGE; MXL12835F; IMG_BAUDRATE=96000000
  AARM.AUserIncludes: ..\common\config_files
  OBJCOPY.OOCOutputFile: aws_tests.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: XIP_IMAGE=1
  ILINK.IlinkIcfFile: ..\..\..\..\lib\third_party\mcu_vendor\nxp\LPC54018\iar\LPC54018_spifi_flash_data.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application_code
    ../../../../demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
    ../common/application_code/: main.c
  group application_code/common_tests/crypto
    ../../../common/crypto/: aws_test_crypto.c
  group application_code/common_tests/framework
    ../../../common/framework/: aws_test_framework.c
  group application_code/common_tests/greengrass
    ../../../common/greengrass/: aws_test_greengrass_discovery.c aws_test_helper_secure_connect.c
  group application_code/common_tests/include
    ../../../common/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_dev_mode_key_provisioning.h aws_logging_task.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h
  group application_code/common_tests/logging
    ../../../../demos/common/logging/: aws_logging_task_dynamic_buffers.c
  group application_code/common_tests/memory_leak
    ../../../common/memory_leak/: aws_memory_leak.c
  group application_code/common_tests/mqtt
    ../../../common/mqtt/: aws_test_mqtt_agent.c aws_test_mqtt_lib.c
  group application_code/common_tests/pkcs11
    ../../../common/pkcs11/: aws_test_pkcs11.c
  group application_code/common_tests/posix
    ../../../common/posix/: aws_test_posix_clock.c aws_test_posix_mqueue.c aws_test_posix_pthread.c aws_test_posix_semaphore.c aws_test_posix_stress.c aws_test_posix_timer.c aws_test_posix_utils.c
  group application_code/common_tests/secure_sockets
    ../../../common/secure_sockets/: aws_test_tcp.c
    ../../../common/secure_sockets/portable/nxp/lpc54018iotmodule/: aws_test_tcp_portable.h
  group application_code/common_tests/shadow
    ../../../common/shadow/: aws_test_shadow.c
  group application_code/common_tests/test_runner
    ../../../common/test_runner/: aws_test_runner.c
  group application_code/common_tests/tls
    ../../../common/tls/: aws_test_tls.c
  group application_code/common_tests/wifi
    ../../../common/wifi/: aws_test_wifi.c
  group application_code/nxp_code
    ../common/application_code/nxp_code/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group config_files
    ../common/config_files/: aws_bufferpool_config.h aws_ggd_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_pkcs11_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h
  group lib/aws/bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib/aws/crypto
    ../../../../lib/crypto/: aws_crypto.c
  group lib/aws/FreeRTOS
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib/aws/FreeRTOS/portable/IAR/ARM_CM4F
    ../../../../lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib/aws/FreeRTOS/portable/MemMang
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_4.c
  group lib/aws/FreeRTOS-Plus-POSIX/include
    ../../../../lib/FreeRTOS-Plus-POSIX/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_internal.h
    ../../../../lib/FreeRTOS-Plus-POSIX/include/portable/nxp/lpc54018iotmodule/: FreeRTOS_POSIX_portable.h
    ../../../../lib/FreeRTOS-Plus-POSIX/include/portable/: FreeRTOS_POSIX_portable_default.h
  group lib/aws/FreeRTOS-Plus-POSIX/source
    ../../../../lib/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group lib/aws/greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib/aws/include
    ../../../../lib/include/: aws_crypto.h aws_greengrass_discovery.h aws_mqtt_agent.h aws_mqtt_lib.h aws_ota_agent.h aws_pkcs11.h aws_secure_sockets.h aws_shadow.h aws_system_init.h aws_tls.h aws_wifi.h event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group lib/aws/include/FreeRTOS_POSIX
    ../../../../lib/include/FreeRTOS_POSIX/: errno.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group lib/aws/include/FreeRTOS_POSIX/sys
    ../../../../lib/include/FreeRTOS_POSIX/sys/: types.h
  group lib/aws/include/private
    ../../../../lib/include/private/: aws_bufferpool.h aws_default_root_certificates.h aws_doubly_linked_list.h aws_ggd_config_defaults.h aws_helper_secure_connect.h aws_lib_init.h aws_mqtt_agent_config_defaults.h aws_mqtt_buffer.h aws_mqtt_config_defaults.h aws_ota_cbor.h aws_ota_pal.h aws_ota_types.h aws_rsprintf.h aws_secure_sockets_config_defaults.h aws_shadow_config_defaults.h aws_shadow_json.h deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group lib/aws/mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib/aws/pkcs11
    ../../../../lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../lib/pkcs11/portable/nxp/lpc54018iotmodule/: aws_pkcs11_pal.c hw_poll.c
  group lib/aws/secure_sockets
    ../../../../lib/secure_sockets/portable/nxp/lpc54018iotmodule/: aws_secure_sockets.c
  group lib/aws/shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib/aws/tls
    ../../../../lib/tls/: aws_tls.c
  group lib/aws/utils
    ../../../../lib/utils/: aws_system_init.c
  group lib/aws/wifi
    ../../../../lib/wifi/portable/nxp/lpc54018iotmodule/: aws_wifi.c
  group lib/third_party/jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c jsmn.h
  group lib/third_party/mbedtls/include
    ../../../../lib/third_party/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group lib/third_party/mbedtls/source
    ../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group lib/third_party/mcu_vendor/drivers
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/drivers/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_emc.c fsl_emc.h fsl_enet.c fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2s.c fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_pint.c fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spi.c fsl_spi_dma.c fsl_spifi.c fsl_spifi.h fsl_usart.c fsl_usart.h mflash_drv.c mflash_drv.h mflash_file.c mflash_file.h
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/log/: fsl_log.c fsl_log.h
  group lib/third_party/mcu_vendor/middleware/osa
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/usb/osa/: usb_osa.h usb_osa_freertos.c usb_osa_freertos.h
  group lib/third_party/mcu_vendor/middleware/usb/device/include
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/usb/device/: usb_device.h
  group lib/third_party/mcu_vendor/middleware/usb/device/source
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group lib/third_party/mcu_vendor/middleware/usb/device/source/lpcip3511
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group lib/third_party/mcu_vendor/middleware/usb/include
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group lib/third_party/mcu_vendor/middleware/utilities
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/: fsl_assert.c fsl_debug_console_conf.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/io/: fsl_io.c fsl_io.h
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/str/: fsl_str.c fsl_str.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/api_interface
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/bmi
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/bmi/: bmi.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/driver
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/hcd
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/hcd/: hcd_api.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/htc
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/htc/: htc.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/hcd/: spi_hcd.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/hw_interface
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/include
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/qapi
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/reorder
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/stack_common
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/stack_common/: common_stack_offload.h
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/storerecall/: dset_api.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/storerecall
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/storerecall/: dset.c storerecall.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/util
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/util/: util.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/common_src/wmi
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/custom_src/api_interface
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/custom_src/driver
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/custom_src/hw_interface
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/custom_src/include
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/include/: a_config.h a_osapi.h a_types.h cust_netbuf.h custom_wlan_api.h wlan_config.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/custom_src/qapi
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group lib/third_party/mcu_vendor/middleware/wifi_qca/custom_src/stack_custom
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h qca_structs.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/include
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h pmu.h targaddrs.h wlan_defs.h wmi.h
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/: atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h qcom_api.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/include/AR6002
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/include/AR6002/hw2.0/hw
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_apb_map.h hw20_gpio_reg.h hw20_mbox_host_reg.h hw20_mbox_reg.h hw20_rtc_reg.h hw20_si_reg.h hw20_uart_reg.h hw20_vmc_reg.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/include/AR6002/hw4.0/hw
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_reg.h hw40_rtc_wlan_reg.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/port
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/port/: wifi_common.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/port/drivers/flexcomm_freertos
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/port/drivers/flexcomm_freertos/: wifi_spi.c wifi_spi.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/port/env/freertos
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/port/env/freertos/: wifi_env.c wifi_env.h wifi_env_port.h wifi_port.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/port/shields
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/port/boards/lpc54018iotmodule/freertos/: wifi_shield.c
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/port/boards/clickbrd_tread/freertos/: wifi_shield.h
  group lib/third_party/mcu_vendor/middleware/wifi_qca/port/shields/gt202
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/middleware/wifi_qca/port/boards/clickbrd_tread/freertos/gt202/: wifi_shield_gt202.h
  group lib/third_party/mcu_vendor/startup
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/iar/: startup_LPC54018.s
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/: system_LPC54018.c system_LPC54018.h
  group lib/third_party/mcu_vendor/utilities
    ../../../../lib/third_party/mcu_vendor/nxp/LPC54018/utilities/: fsl_debug_console.c fsl_debug_console.h
  group lib/third_party/unity
    ../../../../lib/third_party/unity/src/: unity.c
    ../../../../lib/third_party/unity/extras/fixture/src/: unity_fixture.c
  group lib/third_party/unity/include
    ../../../../lib/third_party/unity/src/: unity.h unity_internals.h
    ../../../../lib/third_party/unity/extras/fixture/src/: unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
