# IAR project libxz.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: SDK_VERSION="V6.0.r4..p1"; _NO_DEFINITIONS_IN_HEADER_FILES; TARGET_OS_LINUX=1; LINUX32=1; __KINOMA_IPP__=1; KINOMA_MP3=1; KINOMA_FAST_HUFFMAN=1; _GNU_SOURCE; mxRun=1; mxMC=1; XS_ARCHIVE=1; _DEBUG=1; mxDebug=1; mxReport=0; mxStress=1; mxProfile=0; BUILT_4_MC=1; __SSLIBC__=1; _ENABLE_THREAD_SUPPORT_; MBEDTLS_CONFIG_FILE=<default.h>
  ICCARM.PreInclude: $WS_DIR$\bin\mw300_defconfig\autoconf.h
  ICCARM.CCIncludePath2: $WS_DIR$\.; $WS_DIR$\sdk\src\incl\sdk; $WS_DIR$\sdk\src\incl\sdk\crypto; $WS_DIR$\sdk\src\incl\sdk\drivers; $WS_DIR$\sdk\src\incl\sdk\drivers\mw300; $WS_DIR$\sdk\src\incl\sdk\drivers\mw300\regs; $WS_DIR$\sdk\src\incl\sdk\drivers\wlan; $WS_DIR$\sdk\src\incl\sdk\drivers\bt; $WS_DIR$\sdk\src\incl\libc\iar; $WS_DIR$\sdk\src\boards; $WS_DIR$\sdk\src\incl\ble\include; $WS_DIR$\sdk\src\incl\ble\fp0; $WS_DIR$\sdk\src\middleware\audio\mp3_decoder\inc; $WS_DIR$\sdk\src\bt\btdriver; $WS_DIR$\sdk\src\incl\platform\os\freertos; $WS_DIR$\sdk\external\freertos\Source\include\; $WS_DIR$\sdk\external\freertos\; $WS_DIR$\sdk\external\freertos\Source\portable\IAR\ARM_CM4F; $WS_DIR$\sdk\src\incl\platform\net\lwip; $WS_DIR$\sdk\external\lwip\src\include\; $WS_DIR$\sdk\external\lwip\src\include\ipv4; $WS_DIR$\sdk\external\lwip\src\include\ipv6; $WS_DIR$\sdk\external\lwip\contrib\port\FreeRTOS\wmsdk\; $WS_DIR$\sdk\external\nghttp2\lib\includes; $WS_DIR$\sdk\external\usb-host\incl; $WS_DIR$\sdk\external\aws_iot\include; $WS_DIR$\sdk\external\mbedtls\upstream\include; $WS_DIR$\sdk\external\mbedtls\port; $WS_DIR$\sdk\external\mbedtls\helper_api; $WS_DIR$\sdk\external\mbedtls\config; $WS_DIR$\sdk\src\incl\libc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libxz.a
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; SDK_VERSION="V6.0.r4..p1"; _NO_DEFINITIONS_IN_HEADER_FILES; TARGET_OS_LINUX=1; LINUX32=1; __KINOMA_IPP__=1; KINOMA_MP3=1; KINOMA_FAST_HUFFMAN=1; _GNU_SOURCE; mxRun=1; mxMC=1; XS_ARCHIVE=1; _DEBUG=1; mxDebug=1; mxReport=0; mxStress=1; mxProfile=0; BUILT_4_MC=1; __SSLIBC__=1; _ENABLE_THREAD_SUPPORT_; MBEDTLS_CONFIG_FILE=<default.h>
  ICCARM.CCOptStrategy: 0
  group (top)
    $WS_DIR$/sdk/src/middleware/xz/: xz_crc32.c xz_dec_lzma2.c xz_dec_stream.c decompress.c
