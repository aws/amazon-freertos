# IAR project SDKProject.ewp, settings and files
configuration W60X SDK Project (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; WM_W600; __inline=inline; __inline__=inline; _CTYPE
  ICCARM.CCIncludePath2: ..\..\..\Include; ..\..\..\Include\App; ..\..\..\Include\Driver; ..\..\..\Include\Net; ..\..\..\Include\OS; ..\..\..\Include\Platform; ..\..\..\Include\WiFi; ..\..\..\Demo; ..\..\..\Demo\console; ..\..\..\Platform\Inc; ..\..\..\Platform\Boot\iccarm; ..\..\..\Platform\Common\crypto; ..\..\..\Platform\Common\crypto\digest; ..\..\..\Platform\Common\crypto\keyformat; ..\..\..\Platform\Common\crypto\math; ..\..\..\Platform\Common\crypto\prng; ..\..\..\Platform\Common\crypto\pubkey; ..\..\..\Platform\Common\crypto\symmetric; ..\..\..\Platform\Common\Params; ..\..\..\Platform\Common\fwup; ..\..\..\Platform\Common\mem; ..\..\..\Platform\Common\utils; ..\..\..\Src\Network\lwip2.0.3\include; ..\..\..\Src\OS\RTOS\include; ..\..\..\Src\App\polarssl\include; ..\..\..\Src\App\matrixssl; ..\..\..\Src\App\libcoap\include; ..\..\..\Src\App\iperf; ..\..\..\Src\App\OTA; ..\..\..\Src\App\dhcpserver; ..\..\..\Src\App\dnsserver; ..\..\..\Src\App\httpclient; ..\..\..\Src\App\libcoap\include; ..\..\..\Src\App\libwebsockets-2.1-stable; ..\..\..\Src\App\ping; ..\..\..\Src\App\wm_atcmd; ..\..\..\Src\App\web; ..\..\..\Src\App\mqtt; ..\..\..\Src\Network\api; ..\..\..\Src\App\mDNS\mDNSCore; ..\..\..\Src\App\mDNS\mDNSPosix; ..\..\..\Platform\Boot\iccarm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SDKProject.bin
  postbuild: makeimg.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: w60x.out
  ILINK.IlinkIcfFile: link_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cJSON
    ../../../Src/App/cJSON/: cJSON.c
  group Cmd
    ../../../Src/App/wm_atcmd/: wm_cmd.c
  group demo
    ../../../Demo/: wm_7816_demo.c wm_adc_demo.c wm_alljoyn_led_demo.c wm_apsta_demo.c Wm_cloud_demo.c wm_connect_net_demo.c wm_crypt_demo.c wm_crypt_hard_demo.c wm_dlna_mediarender_demo.c wm_dlna_mediarender_demo_vs1053.c wm_flash_demo.c wm_gpio_demo.c wm_http_demo.c wm_i2c_demo.c wm_i2s_demo.c wm_iperf_auto_demo.c wm_master_spi_demo.c wm_mcast_demo.c wm_ntp_demo.c wm_pmu_demo.c wm_pwm_demo.c wm_raw_socket_client_demo.c wm_raw_socket_server_demo.c wm_rsa_demo.c wm_rtc_demo.c wm_scan_demo.c wm_slave_spi_demo.c wm_socket_client_demo.c wm_socket_fwup_demo.c wm_socket_server_demo.c wm_socket_server_sel_demo.c wm_softap_demo.c wm_ssl_server_demo.c wm_timer_demo.c wm_uart_demo.c wm_udp_demo.c wm_websockets_demo.c wm_wps_demo.c
    ../../../Demo/console/: wm_demo_console_task.c
  group DhcpServer
    ../../../Src/App/dhcpserver/: dhcp_server.c
  group DnsServer
    ../../../Src/App/dnsserver/: dns_server.c
  group HttpClient
    ../../../Src/App/httpclient/: wm_http_compile.c
  group Iperf
    ../../../Src/App/iperf/: iperf_api.c iperf_client_api.c iperf_error.c iperf_locale.c iperf_main.c iperf_net.c iperf_server_api.c iperf_tcp.c iperf_timer.c iperf_udp.c iperf_units.c iperf_util.c tcp_info.c tcp_window_size.c wm_perf.c
  group libcoap
    ../../../Src/App/libcoap/: address.c async.c block.c coap_io_lwip.c coap_time.c debug.c encode.c hashkey.c mem_libcoap.c net.c option.c pdu.c resource.c str.c subscribe.c uri_libcoap.c
  group LWIP
    ../../../Src/Network/: lwip2.0.3.c
  group main
    ../../../App/: main.c
  group MatrixSSL
    ../../../Src/App/matrixssl/: wm_matrixssl_compile.c
  group mDNS
    ../../../Src/App/mDNS/mDNSCore/: mDNS.c
    ../../../Src/App/mDNS/mDNSPosix/: mDNSPosix.c
  group MQTT
    ../../../Src/App/mqtt/: libemqtt.c
  group NTP
    ../../../Src/App/ntp/: ntp_client.c
  group oneshotcfg
    ../../../Src/App/oneshotconfig/: libairkiss_log.lib wm_oneshot_airkiss.c wm_oneshot_lsd.c wm_wifi_oneshot.c
  group OS
    ../../../Src/OS/RTOS/: wm_rtos.c
  group OTA
    ../../../Src/App/OTA/: wm_http_fwup.c wm_socket_fwup.c
  group Ping
    ../../../Src/App/ping/: ping.c
  group Platform
    ../../../Platform/Boot/iccarm/: misc.c port_iar.s retarget_iar.c startup_iar.s
    ../../../Platform/Sys/: tls_sys.c wm_main.c
    ../../../Platform/Common/: wm_common.c
    ../../../Platform/Drivers/: wm_driver.c
  group polarssl
    ../../../Src/App/polarssl/library/: arc4.c asn1parse.c base64.c cipher.c cipher_wrap.c error.c md.c md_wrap.c pem.c polarssl_bignum.c polarssl_debug.c polarssl_md5.c polarssl_sha1.c rsa.c ssl_cli.c ssl_tls.c x509parse.c
  group SSLServer
    ../../../Src/App/sslserver/: wm_ssl_server.c
  group WebServer
    ../../../Src/App/web/: fs.c httpd.c web.c
  group websocket
    ../../../Src/App/libwebsockets-2.1-stable/: base64-decode.c client-handshake.c client-parser.c client.c context.c handshake.c header.c libwebsockets.c lws-plat-wm.c output.c parsers.c pollfd.c service.c ssl-client.c ssl.c
  group wlan_lib
    ../../../Lib/IAR/: wlan.a
