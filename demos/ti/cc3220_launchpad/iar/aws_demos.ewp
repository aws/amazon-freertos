# IAR project aws_demos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3220SF TexasInstruments CC3220SF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; __little_endian__
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v1_40_01_00\source; ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v1_40_01_00\source\ti\drivers\net\wifi; ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v1_40_01_00\kernel\freertos\posix; ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v1_40_01_00\kernel\freertos\posix\sys; ..\common; ..\..\..\..\lib; ..\..\..\..\lib\ota\portable\ti\cc3220_launchpad; ..\..\..\..\lib\include; ..\common\application_code\ti_code; ..\..\..\common; ..\..\..\..\lib\FreeRTOS\portable\IAR\ARM_CM3; ..\..\..\..\lib\third_party\jsmn; ..\..\..\..\lib\third_party\pkcs11; ..\..\..\..\lib\third_party\tinycbor; ..\..\..\..\lib\third_party\mbedtls\include; ..\common\application_code\ti_code; ..\common\config_files; ..\..\..\..\lib\include\private; ..\..\..\common\include; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLER__
  AARM.AUserIncludes: ..\common\application_code\ti_code; ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v1_40_01_00\source; ..\common\config_files
  OBJCOPY.OOCOutputFile: aws_demos.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v1_40_01_00\source\ti\boards\CC3220SF_LAUNCHXL\CC3220SF_LAUNCHXL_FREERTOS.icf
  ILINK.IlinkExtraOptions: ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v1_40_01_00\source\ti\drivers\net\wifi\iar\rtos\simplelink.a; ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v1_40_01_00\source\ti\devices\cc32xx\driverlib\iar\Release\driverlib.a; ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v1_40_01_00\source\ti\drivers\lib\drivers_cc32xx.arm4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application_code
    ../common/application_code/: main.c
  group application_code/common_demos/include
    ../../../common/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_demo_runner.h aws_dev_mode_key_provisioning.h aws_greengrass_discovery_demo.h aws_hello_world.h aws_logging_task.h aws_shadow_lightbulb_on_off.h aws_subscribe_publish_loop.h aws_tcp_echo_client_single_tasks.h
  group application_code/common_demos/source
    ../../../common/demo_runner/: aws_demo_runner.c
    ../../../common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
    ../../../common/greengrass_connectivity/: aws_greengrass_discovery_demo.c
    ../../../common/mqtt/: aws_hello_world.c aws_subscribe_publish_loop.c
    ../../../common/logging/: aws_logging_task_dynamic_buffers.c
    ../../../common/ota/: aws_ota_update_demo.c
    ../../../common/shadow/: aws_shadow_lightbulb_on_off.c
    ../../../common/tcp/: aws_tcp_echo_client_single_task.c
  group application_code/ti_code
    ../common/application_code/ti_code/: Board.h CC3220SF_LAUNCHXL.c CC3220SF_LAUNCHXL.h CC3220SF_LAUNCHXL_FREERTOS.cmd network_if.c network_if.h uart_term.c uart_term.h
  group config_files
    ../common/config_files/: aws_bufferpool_config.h aws_demo_config.h aws_ggd_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h
  group lib/aws/bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib/aws/FreeRTOS
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib/aws/FreeRTOS/portable/IAR/ARM_CM3
    ../../../../lib/FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group lib/aws/FreeRTOS/portable/MemMang
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_4.c
  group lib/aws/greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib/aws/include
    ../../../../lib/include/private/: aws_bufferpool.h aws_default_root_certificates.h aws_doubly_linked_list.h aws_ggd_config_defaults.h aws_helper_secure_connect.h aws_lib_init.h aws_mqtt_agent_config_defaults.h aws_mqtt_buffer.h aws_mqtt_config_defaults.h aws_ota_cbor.h aws_ota_pal.h aws_ota_types.h aws_rsprintf.h aws_secure_sockets_config_defaults.h aws_shadow_config_defaults.h aws_shadow_json.h deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
    ../../../../lib/include/: aws_crypto.h aws_greengrass_discovery.h aws_mqtt_agent.h aws_mqtt_lib.h aws_ota_agent.h aws_pkcs11.h aws_secure_sockets.h aws_shadow.h aws_system_init.h aws_tls.h aws_wifi.h event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group lib/aws/mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib/aws/ota
    ../../../../lib/ota/: aws_ota_agent.c aws_ota_cbor.c aws_rsprintf.c
    ../../../../lib/ota/portable/ti/cc3220_launchpad/: aws_ota_pal.c
  group lib/aws/pkcs11
    ../../../../lib/pkcs11/portable/ti/cc3220_launchpad/: pkcs11.c
  group lib/aws/secure_sockets
    ../../../../lib/secure_sockets/portable/ti/cc3220_launchpad/: aws_secure_sockets.c
  group lib/aws/shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib/aws/utils
    ../../../../lib/utils/: aws_system_init.c
  group lib/aws/wifi
    ../../../../lib/wifi/portable/ti/cc3220_launchpad/: aws_wifi.c
  group lib/third_party/jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c jsmn.h
  group lib/third_party/mbedtls
    ../../../../lib/third_party/mbedtls/library/: base64.c
    ../../../../lib/third_party/mbedtls/include/mbedtls/: base64.h
  group lib/third_party/mcu_vendor/v1.40.01.00_kernel_freertos/dpl
    ../../../../lib/third_party/mcu_vendor/ti/SimpleLink_CC32xx/v1_40_01_00/kernel/freertos/dpl/: ClockP_freertos.c DebugP_freertos.c HwiPCC32XX_freertos.c MutexP_freertos.c PowerCC32XX_freertos.c SemaphoreP_freertos.c SystemP_freertos.c
  group lib/third_party/mcu_vendor/v1.40.01.00_kernel_freertos/posix
    ../../../../lib/third_party/mcu_vendor/ti/SimpleLink_CC32xx/v1_40_01_00/kernel/freertos/posix/: clock_freertos.c errno.h memory_freertos.c mqueue.h mqueue_freertos.c pthread.h pthread_barrier_freertos.c pthread_cond_freertos.c pthread_freertos.c pthread_mutex_freertos.c pthread_rwlock_freertos.c sched.h sched_freertos.c semaphore.h semaphore_freertos.c signal.h sleep_freertos.c time.h timer_freertos.c unistd.h
  group lib/third_party/mcu_vendor/v1.40.01.00_kernel_freertos/posix/sys
    ../../../../lib/third_party/mcu_vendor/ti/SimpleLink_CC32xx/v1_40_01_00/kernel/freertos/posix/sys/: signal.h time.h types.h
  group lib/third_party/mcu_vendor/v1.40.01.00_kernel_freertos/startup
    ../../../../lib/third_party/mcu_vendor/ti/SimpleLink_CC32xx/v1_40_01_00/kernel/freertos/startup/: startup_cc32xx_iar.c
  group lib/third_party/tinycbor
    ../../../../lib/third_party/tinycbor/: assert_p.h cbor.h cborconstants_p.h cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c compilersupport_p.h extract_number_p.h math_support_p.h
