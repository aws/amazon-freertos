# IAR project aws_demos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3220SF TexasInstruments CC3220SF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; __little_endian__
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v2_10_00_04\source; ..\common; ..\..\..\..\lib; ..\..\..\..\lib\ota\portable\ti\cc3220_launchpad; ..\..\..\..\lib\include; ..\common\application_code\ti_code; ..\..\..\common; ..\..\..\..\lib\FreeRTOS\portable\IAR\ARM_CM3; ..\..\..\..\lib\third_party\jsmn; ..\..\..\..\lib\third_party\pkcs11; ..\..\..\..\lib\third_party\tinycbor; ..\..\..\..\lib\third_party\mbedtls\include; ..\common\application_code\ti_code; ..\common\config_files; ..\..\..\..\lib\include\private; ..\..\..\common\include; $TOOLKIT_DIR$\inc; $TOOLKIT_DIR$\inc\c; ..\..\..\..\lib\include\FreeRTOS_POSIX; ..\..\..\..\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\..\lib\FreeRTOS-Plus-POSIX\include\portable\ti\cc3220_launchpad
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ASSEMBLER__
  AARM.AUserIncludes: ..\common\application_code\ti_code; ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v2_10_00_04\source; ..\common\config_files
  OBJCOPY.OOCOutputFile: aws_demos.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v2_10_00_04\source\ti\boards\CC3220SF_LAUNCHXL\CC3220SF_LAUNCHXL_FREERTOS.icf
  ILINK.IlinkExtraOptions: ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v2_10_00_04\source\ti\drivers\net\wifi\iar\rtos\simplelink.a; ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v2_10_00_04\source\ti\devices\cc32xx\driverlib\iar\Release\driverlib.a; ..\..\..\..\lib\third_party\mcu_vendor\ti\SimpleLink_CC32xx\v2_10_00_04\source\ti\drivers\lib\drivers_cc32xx.arm4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application_code
    ../common/application_code/: main.c
  group application_code/common_demos/include
    ../../../common/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_demo_runner.h aws_dev_mode_key_provisioning.h aws_greengrass_discovery_demo.h aws_hello_world.h aws_logging_task.h aws_shadow_lightbulb_on_off.h aws_subscribe_publish_loop.h aws_tcp_echo_client_single_tasks.h
  group application_code/common_demos/source
    ../../../common/demo_runner/: aws_demo_runner.c
    ../../../common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
    ../../../common/greengrass_connectivity/: aws_greengrass_discovery_demo.c
    ../../../common/mqtt/: aws_hello_world.c aws_subscribe_publish_loop.c
    ../../../common/logging/: aws_logging_task_dynamic_buffers.c
    ../../../common/ota/: aws_ota_update_demo.c
    ../../../common/shadow/: aws_shadow_lightbulb_on_off.c
    ../../../common/tcp/: aws_tcp_echo_client_single_task.c
  group application_code/ti_code
    ../common/application_code/ti_code/: Board.h CC3220SF_LAUNCHXL.c CC3220SF_LAUNCHXL.h CC3220SF_LAUNCHXL_FREERTOS.cmd network_if.c network_if.h uart_term.c uart_term.h
  group config_files
    ../common/config_files/: aws_bufferpool_config.h aws_demo_config.h aws_ggd_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_ota_agent_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h
  group lib/aws/bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib/aws/FreeRTOS
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib/aws/FreeRTOS/portable/IAR/ARM_CM3
    ../../../../lib/FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group lib/aws/FreeRTOS/portable/MemMang
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_4.c
  group lib/aws/FreeRTOS-Plus-POSIX/include
    ../../../../lib/FreeRTOS-Plus-POSIX/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_internal.h
    ../../../../lib/FreeRTOS-Plus-POSIX/include/portable/ti/cc3220_launchpad/: FreeRTOS_POSIX_portable.h
    ../../../../lib/FreeRTOS-Plus-POSIX/include/portable/: FreeRTOS_POSIX_portable_default.h
  group lib/aws/FreeRTOS-Plus-POSIX/source
    ../../../../lib/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group lib/aws/greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib/aws/include
    ../../../../lib/include/: aws_crypto.h aws_greengrass_discovery.h aws_mqtt_agent.h aws_mqtt_lib.h aws_ota_agent.h aws_pkcs11.h aws_secure_sockets.h aws_shadow.h aws_system_init.h aws_tls.h aws_wifi.h event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group lib/aws/include/FreeRTOS_POSIX
    ../../../../lib/include/FreeRTOS_POSIX/: errno.h fcntl.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group lib/aws/include/FreeRTOS_POSIX/sys
    ../../../../lib/include/FreeRTOS_POSIX/sys/: types.h
  group lib/aws/include/private
    ../../../../lib/include/private/: aws_bufferpool.h aws_default_root_certificates.h aws_doubly_linked_list.h aws_ggd_config_defaults.h aws_helper_secure_connect.h aws_lib_init.h aws_mqtt_agent_config_defaults.h aws_mqtt_buffer.h aws_mqtt_config_defaults.h aws_ota_cbor.h aws_ota_pal.h aws_ota_types.h aws_rsprintf.h aws_secure_sockets_config_defaults.h aws_shadow_config_defaults.h aws_shadow_json.h deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group lib/aws/mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib/aws/ota
    ../../../../lib/ota/: aws_ota_agent.c aws_ota_cbor.c
    ../../../../lib/ota/portable/ti/cc3220_launchpad/: aws_ota_pal.c
  group lib/aws/pkcs11
    ../../../../lib/pkcs11/portable/ti/cc3220_launchpad/: aws_pkcs11_pal.c
  group lib/aws/secure_sockets
    ../../../../lib/secure_sockets/portable/ti/cc3220_launchpad/: aws_secure_sockets.c
  group lib/aws/shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib/aws/utils
    ../../../../lib/utils/: aws_system_init.c
  group lib/aws/wifi
    ../../../../lib/wifi/portable/ti/cc3220_launchpad/: aws_wifi.c
  group lib/third_party/jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c jsmn.h
  group lib/third_party/mbedTLS/include
    ../../../../lib/third_party/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group lib/third_party/mbedTLS/mbedtls
    ../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group lib/third_party/mcu_vendor/ti/SimpleLink_CC32xx/v2_10_00_04/kernel/dpl
    ../../../../lib/third_party/mcu_vendor/ti/SimpleLink_CC32xx/v2_10_00_04/kernel/freertos/dpl/: ClockP_freertos.c DebugP_freertos.c HwiPCC32XX_freertos.c MutexP_freertos.c PowerCC32XX_freertos.c SemaphoreP_freertos.c SystemP_freertos.c
  group lib/third_party/mcu_vendor/ti/SimpleLink_CC32xx/v2_10_00_04/kernel/startup
    ../../../../lib/third_party/mcu_vendor/ti/SimpleLink_CC32xx/v2_10_00_04/kernel/freertos/startup/: startup_cc32xx_iar.c
  group lib/third_party/tinycbor
    ../../../../lib/third_party/tinycbor/: assert_p.h cbor.h cborconstants_p.h cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c compilersupport_p.h extract_number_p.h math_support_p.h
