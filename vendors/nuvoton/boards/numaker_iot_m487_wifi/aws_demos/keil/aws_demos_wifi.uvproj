# Keil uVision project aws_demos_wifi.uvproj, settings and files
target aws_demos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: aws_demos +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx
  c misc: --diag_suppress=550,177,C4017,111,2770,223
  c include: ..\..\..\..\..\..\modules\libraries\3rdparty\mcu_vendor\nuvoton\numaker_iot_m487_wifi\Device\Nuvoton\numaker_iot_m487_wifi\Include;..\..\..\..\..\..\modules\libraries\3rdparty\mcu_vendor\nuvoton\numaker_iot_m487_wifi\StdDriver\inc;..\..\..\..\..\..\modules\libraries\3rdparty\mcu_vendor\nuvoton\numaker_iot_m487_wifi\CMSIS\Include;..\..\..\..\..\..\modules\libraries\3rdparty\mcu_vendor\nuvoton\numaker_iot_m487_wifi\middleware\wifi_esp8266;..\..\..\..\..\..\modules\ports\wifi\include;..\..\..\..\..\..\modules\libraries\3rdparty\mbedtls\include;..\..\..\..\..\..\modules\libraries\standard\utils\include;..\..\..\..\..\..\modules\libraries\3rdparty\jsmn;..\..\..\..\..\..\modules\libraries\3rdparty\pkcs11;..\..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\..\freertos_kernel\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\vendors\nuvoton\sdk\Device\Nuvoton\numaker_iot_m487_wifi\Include;..\..\..\..\..\..\vendors\nuvoton\sdk\CMSIS\Include;..\..\..\..\..\..\vendors\nuvoton\sdk\StdDriver\inc;..\..\..\..\..\..\modules\libraries\standard\common\include;..\..\..\..\..\..\demos\include;..\..\..\..\..\..\modules\libraries\standard\provisioning\include;..\..\..\..\..\..\modules\ports\pkcs11\include;..\..\..\..\..\..\modules\ports\secure_sockets\include;..\..\..\..\..\..\vendors\nuvoton\boards\numaker_iot_m487_wifi\aws_demos\common\config_files;..\..\..\..\..\..\modules\libraries\aws\greengrass\include;..\..\..\..\..\..\modules\libraries\standard\mqtt\include;..\..\..\..\..\..\modules\libraries\standard\common\include;..\..\..\..\..\..\modules\libraries\standard\provisioning\include;..\..\..\..\..\..\modules\libraries\standard\common\include\private;..\..\..\..\..\..\modules\libraries\standard\common\include\platform;..\..\..\..\..\..\modules\libraries\standard\common\include\types;..\..\..\..\..\..\demos\network_manager;..\..\..\..\..\..\demos\tcp;..\..\..\..\..\..\vendors\nuvoton\sdk\middleware\wifi_esp8266;..\..\..\..\..\..\modules\libraries\standard\crypto\include;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\include\lwip;..\..\..\..\..\..\modules\libraries\aws\shadow\include;..\..\..\..\..\..\modules\libraries\standard\tls\include;..\..\..\..\..\..\modules\ports\pkcs11\mbedtls;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\include;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\test\fuzz;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\portable\arch;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\portable;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\include\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group CMSIS
    ../../../../../../vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/ARM/: startup_M480.s
    ../../../../../../vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/: system_M480.c
  group User
    ../common/application_code/nuvoton_code/: entropy_hardware_poll.c
    ../common/application_code/: main.c
  group FreeRTOS
    ../../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../freertos_kernel/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group NVT-Library
    ../../../../../../vendors/nuvoton/sdk/StdDriver/src/: retarget.c clk.c crypto.c fmc.c sys.c uart.c
  group demos
    ../../../../../../demos/demo_runner/: iot_demo_runner.c iot_demo_afr.c aws_demo.c
    ../../../../../../demos/tcp/: aws_tcp_echo_client_single_task.c
    ../../../../../../modules/libraries/standard/common/logging/: aws_logging_task_dynamic_buffers.c
    ../../../../../../modules/libraries/standard/provisioning/src/: aws_dev_mode_key_provisioning.c
    ../../../../../../demos/greengrass_connectivity/: aws_greengrass_discovery_demo.c
    ../../../../../../demos/mqtt/: iot_demo_mqtt.c
  group wifi
    ../../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/wifi/: aws_wifi.c
    ../../../../../../vendors/nuvoton/sdk/middleware/wifi_esp8266/: esp8266_wifi.c
  group lib-crypto
    ../../../../../../modules/libraries/standard/crypto/src/: aws_crypto.c
  group lib-mqtt
    ../../../../../../modules/libraries/standard/mqtt/src/: aws_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group lib-grenngrass
    ../../../../../../modules/libraries/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib-pkcs11
    ../../../../../../modules/ports/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/pkcs11/: aws_pkcs11_pal.c
  group lib-secure_sockets
    ../../ports/secure_sockets/: aws_secure_sockets.c
  group lib-shadow
    ../../../../../../modules/libraries/aws/shadow/src/: aws_shadow.c aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_subscription.c
  group lib-tls
    ../../../../../../modules/libraries/standard/tls/src/: aws_tls.c
  group lib-utils
    ../../../../../../modules/libraries/standard/utils/src/: aws_system_init.c
  group 3rd-jsmn
    ../../../../../../modules/libraries/3rdparty/jsmn/: jsmn.c
  group 3rd-mbedtls
    ../../../../../../modules/libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c platform_util.c
  group modules/libraries/standard/common
    ../../../../../../modules/libraries/standard/common/platform/: iot_clock_afr.c iot_network_afr.c iot_threads_afr.c
    ../../../../../../modules/libraries/standard/common/taskpool/: iot_taskpool.c
    ../../../../../../modules/libraries/standard/common/: iot_init.c iot_json_utils.c
    ../../../../../../modules/libraries/standard/common/logging/: iot_logging.c
  group demos/network_manager
    ../../../../../../demos/network_manager/: aws_iot_demo_network.c aws_iot_network_manager.c
