# Keil uVision project aws_tests_wifi.uvproj, settings and files
target aws_tests (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: aws_tests +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MBEDTLS_USER_CONFIG_FILE=\"mbedtls_user_config.h\" UNITY_INCLUDE_CONFIG_H RVDS_ARMCM4_NUC4xx __LITTLE_ENDIAN__ AMAZON_FREERTOS_ENABLE_UNIT_TESTS M487
  c misc: --diag_suppress=550,177,C4017,111,2770,223
  c include: ..\..\..\..\sdk\Device\Nuvoton\numaker_iot_m487_wifi\Include;..\..\..\..\sdk\StdDriver\inc;..\..\..\..\sdk\CMSIS\Include;..\..\..\..\sdk\middleware\wifi_esp8266;..\..\..\..\..\..\modules\ports\wifi\include;..\..\..\..\..\..\modules\libraries\3rdparty\mbedtls\include;..\..\..\..\..\..\modules\libraries\standard\utils\include;..\..\..\..\..\..\modules\libraries\3rdparty\jsmn;..\..\..\..\..\..\modules\libraries\3rdparty\pkcs11;..\..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\..\freertos_kernel\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\vendors\nuvoton\sdk\Device\Nuvoton\numaker_iot_m487_wifi\Include;..\..\..\..\..\..\vendors\nuvoton\sdk\CMSIS\Include;..\..\..\..\..\..\vendors\nuvoton\sdk\StdDriver\inc;..\..\..\..\..\..\modules\libraries\standard\common\include;..\..\..\..\..\..\test\include;..\..\..\..\..\..\modules\libraries\standard\provisioning\include;..\..\..\..\..\..\modules\ports\pkcs11\include;..\..\..\..\..\..\modules\ports\secure_sockets\include;..\..\..\..\..\..\modules\libraries\aws\greengrass\include;..\..\..\..\..\..\modules\libraries\standard\mqtt\include;..\..\..\..\..\..\modules\libraries\standard\common\include;..\..\..\..\..\..\modules\libraries\standard\provisioning\include;..\..\..\..\..\..\modules\libraries\standard\common\include\private;..\..\..\..\..\..\modules\libraries\standard\common\include\platform;..\..\..\..\..\..\modules\libraries\standard\common\include\types;..\..\..\..\..\..\demos\network_manager;..\..\..\..\..\..\demos\tcp;..\..\..\..\..\..\vendors\nuvoton\sdk\middleware\wifi_esp8266;..\..\..\..\..\..\modules\libraries\standard\crypto\include;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\include\lwip;..\..\..\..\..\..\modules\libraries\aws\shadow\include;..\..\..\..\..\..\modules\libraries\standard\tls\include;..\..\..\..\..\..\modules\ports\pkcs11\mbedtls;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\include;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\test\fuzz;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\portable\arch;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\portable;..\..\..\..\..\..\modules\libraries\3rdparty\lwip\src\include\lwip;..\..\..\..\..\..\modules\libraries\3rdparty\unity\src;..\..\..\..\..\..\modules\libraries\3rdparty\unity\extras\fixture\src;..\..\..\..\..\..\modules\libraries\standard\mqtt\src;..\..\..\..\..\..\modules\libraries\standard\mqtt\test\access;..\..\..\..\..\..\modules\libraries\aws\greengrass\src;..\..\..\..\..\..\vendors\nuvoton\boards\numaker_iot_m487_wifi\aws_tests\common\config_files;..\..\..\..\..\..\modules\libraries\standard\mqtt\src\private;..\..\..\..\..\..\modules\libraries\standard\freertos_plus_posix\include;..\..\..\..\..\..\modules\libraries\standard\freertos_plus_posix\include\portable\nuvoton\numaker_iot_m487_wifi;..\..\..\..\..\..\modules\ports\posix\include;..\..\..\..\..\..\modules\libraries\aws\shadow\src;..\..\..\..\..\..\modules\libraries\aws\greengrass\test;..\common\application_code\nuvoton_code;..\..\..\..\..\..\modules\ports\posix\include\FreeRTOS_POSIX\;..\..\..\..\..\..\modules\libraries\3rdparty\mbedtls\library;..\..\..\..\..\..\modules\libraries\standard\freertos_plus_tcp\source\portable\Compiler\Keil;..\..\..\..\..\..\modules\libraries\standard\freertos_plus_tcp\source\portable\NetworkInterface\M487;..\..\..\..\..\..\modules\libraries\standard\freertos_plus_tcp\include;..\..\..\..\..\..\modules\libraries\standard\freertos_plus_tcp\test
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group CMSIS
    ../../../../../../vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/ARM/: startup_M480.s
    ../../../../../../vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/: system_M480.c
  group User
    ../common/application_code/nuvoton_code/: entropy_hardware_poll.c
    ../common/application_code/: main.c
  group FreeRTOS
    ../../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../freertos_kernel/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group NVT-Library
    ../../../../../../vendors/nuvoton/sdk/StdDriver/src/: retarget.c clk.c crypto.c fmc.c sys.c uart.c
  group tests
    ../../../../../../test/src/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_afr.c iot_tests_network.c
  group wifi
    ../../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/wifi/: aws_wifi.c
    ../../../../../../vendors/nuvoton/sdk/middleware/wifi_esp8266/: esp8266_wifi.c
    ../../../../../../modules/ports/wifi/test/: aws_test_wifi.c
  group lib-crypto
    ../../../../../../modules/libraries/standard/crypto/test/: aws_test_crypto.c
    ../../../../../../modules/libraries/standard/crypto/src/: aws_crypto.c
  group lib-mqtt
    ../../../../../../modules/libraries/standard/mqtt/test/: aws_test_mqtt_agent.c
    ../../../../../../modules/libraries/standard/mqtt/test/system/: iot_tests_mqtt_system.c
    ../../../../../../modules/libraries/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
    ../../../../../../modules/libraries/standard/mqtt/src/: aws_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group lib-grenngrass
    ../../../../../../modules/libraries/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib-pkcs11
    ../../../../../../modules/ports/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/pkcs11/: aws_pkcs11_pal.c
    ../../../../../../modules/ports/pkcs11/test/: aws_test_pkcs11.c
  group lib-secure_sockets
    ../../ports/secure_sockets/: aws_secure_sockets.c
    ../../../../../../modules/ports/secure_sockets/test/: aws_test_tcp.c
  group lib-shadow
    ../../../../../../modules/libraries/aws/shadow/src/: aws_shadow.c aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_subscription.c
    ../../../../../../modules/libraries/aws/shadow/test/: aws_test_shadow.c
    ../../../../../../modules/libraries/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
    ../../../../../../modules/libraries/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
  group lib-tls
    ../../../../../../modules/libraries/standard/tls/src/: aws_tls.c
    ../../../../../../modules/libraries/standard/tls/test/: aws_test_tls.c
  group lib-utils
    ../../../../../../modules/libraries/standard/utils/src/: aws_system_init.c
  group 3rd-jsmn
    ../../../../../../modules/libraries/3rdparty/jsmn/: jsmn.c
  group 3rd-mbedtls
    ../../../../../../modules/libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c platform_util.c
  group modules/libraries/standard/common
    ../../../../../../modules/libraries/standard/common/platform/: iot_clock_afr.c iot_network_afr.c iot_threads_afr.c
    ../../../../../../modules/libraries/standard/common/taskpool/: iot_taskpool.c
    ../../../../../../modules/libraries/standard/common/: iot_init.c iot_json_utils.c
    ../../../../../../modules/libraries/standard/common/logging/: iot_logging.c aws_logging_task_dynamic_buffers.c
    ../../../../../../modules/libraries/standard/common/static_memory/: aws_iot_static_memory_defender.c aws_iot_static_memory_shadow.c iot_static_memory_common.c iot_static_memory_metrics.c iot_static_memory_mqtt.c iot_static_memory_serializer.c iot_static_memory_taskpool.c
    ../../../../../../modules/libraries/standard/common/test/: aws_memory_leak.c iot_test_platform_clock.c iot_test_platform_threads.c
  group 3rd-unity
    ../../../../../../modules/libraries/3rdparty/unity/src/: unity.c
    ../../../../../../modules/libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group FreeRTOS-test
    ../../../../../../modules/libraries/standard/freertos_plus_posix/test/: aws_test_posix_clock.c aws_test_posix_mqueue.c aws_test_posix_pthread.c aws_test_posix_semaphore.c aws_test_posix_stress.c aws_test_posix_timer.c aws_test_posix_unistd.c aws_test_posix_utils.c
  group FreeRTOS-source
    ../../../../../../modules/libraries/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group lib-std-metrics
    ../../../../../../modules/libraries/standard/metrics/src/: aws_secure_sockets_wrapper_metrics.c iot_metrics.c
  group lib-std-provisioning
    ../../../../../../modules/libraries/standard/provisioning/src/: aws_dev_mode_key_provisioning.c
