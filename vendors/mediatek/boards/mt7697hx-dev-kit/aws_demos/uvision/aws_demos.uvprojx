# Keil uVision project aws_demos.uvprojx, settings and files
target aws_demos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.1
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: aws_demos +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: PCFG_OS=2 _REENT_SMALL PRODUCT_VERSION=7687 MTK_BLE_SMTCN_ENABLE MTK_BT_LWIP_ENABLE MTK_BLE_BQB_TEST_ENABLE MTK_BLE_CLI_ENABLE MTK_BLE_BQB_CLI_ENABLE MTK_HCI_CONSOLE_MIX_ENABLE MTK_MINISUPP_ENABLE MTK_BSPEXT_ENABLE MTK_HAL_LOWPOWER_ENABLE MTK_LWIP_CLI_ENABLE MTK_HTTPCLIENT_SSL_ENABLE MTK_IPERF_ENABLE MTK_SMTCN_ENABLE MTK_CLI_TEST_MODE_ENABLE MTK_WIFI_REPEATER_ENABLE  CONFIG_REPEATER MTK_DEBUG_LEVEL_NONE MTK_WIFI_PRIVILEGE_ENABLE SUPPORT_MBEDTLS __MTK_BLE_ONLY_ENABLE__ MTK_SINGLE_SKU_SUPPORT HAL_DFS_MODULE_ENABLED LWIP_NO_STDINT_H=1 LWIP_TIMEVAL_PRIVATE=1
  c misc: --C99 --diag_error=warning
  c include: ../common/config_files;../common/application_code/mediatek_code/include;../../../../../../freertos_kernel/include;../../../../../../freertos_kernel/portable/RVDS/ARM_CM4F;../../../../../../modules/libraries/standard/common/include;../../../../../../modules/libraries/standard/common/include/private;../../../../../../modules/libraries/standard/utils/include;../../../../../../modules/libraries/3rdparty/pkcs11;../../../../../../modules/libraries/3rdparty/jsmn;../../../../../../modules/libraries/3rdparty/mbedtls/include;../../../../../../modules/libraries/3rdparty/tracealyzer_recorder/Include;../../../../../../modules/libraries/standard/mqtt/include;../../../../../../modules/libraries/standard/provisioning/include;../../../../../../modules/libraries/aws/shadow/include;../../../../../../modules/ports/pkcs11/mbedtls;../../../../../../modules/ports/pkcs11/include;../../../../../../modules/ports/wifi/include;../../../../../../modules/ports/secure_sockets/include/;../../../../../../demos/include;../../../../../../vendors/mediatek/sdk/driver/chip/inc;../../../../../../vendors/mediatek/sdk/driver/chip/mt7687/inc;../../../../../../vendors/mediatek/sdk/driver/chip/mt7687/src/common/include;../../../../../../vendors/mediatek/sdk/driver/chip/mt7687/src/sdio_gen3/include;../../../../../../vendors/mediatek/sdk/driver/CMSIS/Include;../../../../../../vendors/mediatek/sdk/driver/CMSIS/Device/MTK/mt7687/Include;../../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/external_flash/inc;../../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/wifi/inc;../../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/util/inc;../../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/ept/inc;../../../../../../vendors/mediatek/sdk/kernel/service/inc;../../../../../../vendors/mediatek/sdk/kernel/extend/inc;../../../../../../modules/libraries/3rdparty/lwip/src/include;../../../../../../modules/libraries/3rdparty/lwip/src/include/lwip;../../../../../../modules/libraries/3rdparty/lwip/src/include/netif;../../../../../../modules/libraries/3rdparty/lwip/src/portable;../../../../../../modules/libraries/3rdparty/lwip/src/portable/mediatek/include;../../../../../../vendors/mediatek/sdk/middleware/third_party/ping/inc;../../../../../../vendors/mediatek/sdk/middleware/MTK/dhcpd/inc;../../../../../../vendors/mediatek/sdk/middleware/MTK/minicli/inc;../../../../../../vendors/mediatek/sdk/middleware/MTK/minisupp/inc;.;../../../../../../modules/libraries/aws/greengrass/include/;../../../../../../modules/libraries/standard/crypto/include/;../../../../../../modules/libraries/standard/tls/include/;../../../../../../demos/network_manager/
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector
  group demos/mediatek/mt7697hx-dev-kit
    ./: startup_mt7687.s
    ../common/application_code/: main.c lwipopts.c
    ../common/application_code/mediatek_code/source/: ept_eint_var.c ept_gpio_var.c sys_init.c system_mt7687.c
  group demos/common
    ../../../../../../modules/libraries/standard/common/logging/: aws_logging_task_dynamic_buffers.c
    ../../../../../../demos/mqtt/: aws_hello_world.c aws_subscribe_publish_loop.c iot_demo_mqtt.c
    ../../../../../../demos/shadow/: aws_shadow_lightbulb_on_off.c
    ../../../../../../demos/tcp/: aws_tcp_echo_client_separate_tasks.c aws_tcp_echo_client_single_task.c
    ../../../../../../demos/demo_runner/: iot_demo_runner.c iot_demo_afr.c
    ../../../../../../modules/libraries/standard/provisioning/src/: aws_dev_mode_key_provisioning.c
    ../../../../../../demos/greengrass_connectivity/: aws_greengrass_discovery_demo.c
  group lib/FreeRTOS
    ../../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib/crypto
    ../../../../../../modules/libraries/standard/crypto/src/: aws_crypto.c
  group lib/greengrass
    ../../../../../../modules/libraries/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib/mqtt
    ../../../../../../modules/libraries/standard/mqtt/src/: aws_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group lib/pkcs11
    ../../../../../../modules/ports/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/ports/pkcs11/: aws_pkcs11_pal.c
  group lib/secure_sockets
    ../../../../../../modules/ports/secure_sockets/lwip/: aws_secure_sockets.c
  group lib/shadow
    ../../../../../../modules/libraries/aws/shadow/src/: aws_shadow.c aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_subscription.c
  group lib/tls
    ../../../../../../modules/libraries/standard/tls/src/: aws_tls.c
  group lib/utils
    ../../../../../../modules/libraries/standard/utils/src/: aws_system_init.c
  group lib/wifi
    ../../../../../../vendors/mediatek/boards/mt7697hx-dev-kit/ports/wifi/: aws_wifi.c
  group lib/third_party/jsmn
    ../../../../../../modules/libraries/3rdparty/jsmn/: jsmn.c
  group lib/third_party/mbedtls
    ../../../../../../modules/libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c rsa_internal.c platform_util.c
  group lib/third_party/lwip
    ../../../../../../modules/libraries/3rdparty/lwip/src/portable/mediatek/netif/: ethernetif.c
    ../../../../../../modules/libraries/3rdparty/lwip/src/portable/arch/: sys_arch.c
    ../../../../../../modules/libraries/3rdparty/lwip/src/portable/mediatek/: lwip_log.c
    ../../../../../../modules/libraries/3rdparty/lwip/src/core/: pbuf.c tcp_out.c def.c dns.c inet_chksum.c init.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c timeouts.c udp.c ip.c
    ../../../../../../modules/libraries/3rdparty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../modules/libraries/3rdparty/lwip/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c etharp.c
    ../../../../../../modules/libraries/3rdparty/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../../modules/libraries/3rdparty/lwip/src/netif/: ethernet.c
  group mediatek/sdk/driver/chip/mt7687
    ../../../../../../vendors/mediatek/sdk/driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_dfs.c hal_eint.c hal_file.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_misc.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_spi_slave.c hal_uart.c hal_wdt.c
    ../../../../../../vendors/mediatek/sdk/driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gdma_internal.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pdma_internal.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../../vendors/mediatek/sdk/driver/chip/mt7687/src/sdio_gen3/: connsys_bus.c connsys_driver.c connsys_util.c context_dump.c
  group mediatek/sdk/driver/board/mt76x7_hdk
    ../../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/util/src/: io_def.c
    ../../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/wifi/src/: get_profile_string.c misc.c os.c wifi_default_config.c wifi_init.c wifi_os_api.c wifi_profile.c wifi_os_mem.c
    ../../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../../vendors/mediatek/sdk/driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
  group mediatek/sdk/kernel/service
    ../../../../../../vendors/mediatek/sdk/kernel/service/src/: toi.c os_trace_callback.c os_port_callback.c memory_regions.c exception_handler.c context_info_save.c
  group mediatek/sdk/kernel/extend
    ../../../../../../vendors/mediatek/sdk/kernel/extend/src/: wrap_heap.c
    ../../../../../../vendors/mediatek/sdk/kernel/extend/src/RVDS/: port.c port_tick.c
  group mediatek/sdk/dhcpd
    ../../../../../../vendors/mediatek/sdk/middleware/MTK/dhcpd/src/: dhcpd.c
  group mediatek/sdk/ping
    ../../../../../../vendors/mediatek/sdk/middleware/third_party/ping/src/: ping.c
  group mediatek/sdk/minicli
    ../../../../../../vendors/mediatek/sdk/middleware/MTK/minicli/src/: minicli_api.c
  group mediatek/prebuilt
    ../../../../../../vendors/mediatek/sdk/prebuilt/keil/: libhal_core_CM4_Keil.lib libhal_protected_CM4_Keil.lib libkservice_CM4_MT7687_Keil.lib libminicli_CM4_Keil.lib libminisupp_CM4_Keil.lib libwifi_CM4_Keil.lib
  group modules/libraries/standard/common
    ../../../../../../modules/libraries/standard/common/platform/: iot_clock_afr.c iot_network_afr.c iot_threads_afr.c
    ../../../../../../modules/libraries/standard/common/taskpool/: iot_taskpool.c
    ../../../../../../modules/libraries/standard/common/: iot_init.c iot_json_utils.c
    ../../../../../../modules/libraries/standard/common/logging/: iot_logging.c
  group demos/network_manager
    ../../../../../../demos/network_manager/: aws_iot_demo_network.c aws_iot_network_manager.c
