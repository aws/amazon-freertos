# IAR project aws_demos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54018 NXP LPC54018
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; XIP_IMAGE; CPU_LPC54018; SDK_DEBUGCONSOLE=1; BOARD_USE_VIRTUALCOM; USB_STACK_FREERTOS; USB_STACK_USE_DEDICATED_RAM=1; BOARD_DEBUG_UART_TYPE=DEBUG_CONSOLE_DEVICE_TYPE_USBCDC; CPU_LPC54018JET180=1; USE_RTOS=1; FSL_RTOS_FREE_RTOS; A_LITTLE_ENDIAN; _DLIB_FILE_DESCRIPTOR=1; __little_endian__=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\freertos_kernel\include; ..\..\..\..\LPC54018; ..\..\..\..\LPC54018\drivers; ..\..\..\..\LPC54018\cmsis_drivers; ..\..\..\..\LPC54018\middleware\wifi_qca; ..\..\..\..\LPC54018\middleware\wifi_qca\common_src\hcd; ..\..\..\..\LPC54018\middleware\wifi_qca\common_src\include; ..\..\..\..\LPC54018\middleware\wifi_qca\common_src\stack_common; ..\..\..\..\LPC54018\middleware\wifi_qca\common_src\wmi; ..\..\..\..\LPC54018\middleware\wifi_qca\custom_src\include; ..\..\..\..\LPC54018\middleware\wifi_qca\custom_src\stack_custom; ..\..\..\..\LPC54018\middleware\wifi_qca\include; ..\..\..\..\LPC54018\middleware\wifi_qca\include\AR6002; ..\..\..\..\LPC54018\middleware\wifi_qca\include\AR6002\hw2.0\hw; ..\..\..\..\LPC54018\middleware\wifi_qca\port; ..\..\..\..\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos; ..\..\..\..\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos\gt202; ..\..\..\..\LPC54018\middleware\wifi_qca\port\drivers\flexcomm_freertos; ..\..\..\..\LPC54018\middleware\wifi_qca\port\env\freertos; ..\..\..\..\LPC54018\middleware\usb\device; ..\..\..\..\LPC54018\middleware\usb\include; ..\..\..\..\LPC54018\middleware\usb\osa; ..\..\..\..\LPC54018\utilities; ..\..\..\..\LPC54018\utilities\io; ..\..\..\..\LPC54018\utilities\log; ..\..\..\..\LPC54018\utilities\str; ..\..\..\..\LPC54018\CMSIS\Include; ..\common\config_files; ..\common\application_code\nxp_code; ..\..\..\..\..\..\demos\include; ..\..\..\..\..\..\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\demos\network_manager; ..\..\..\..\..\..\modules\ports\ble\include\private; ..\..\..\..\..\..\modules\libraries\standard\common\include\private; ..\..\..\..\..\..\modules\libraries\standard\provisioning\include; ..\..\..\..\..\..\modules\ports\pkcs11\include; ..\..\..\..\..\..\modules\libraries\standard\crypto\include; ..\..\..\..\..\..\modules\libraries\standard\common\include; ..\..\..\..\..\..\modules\ports\secure_sockets\include; ..\..\..\..\..\..\modules\libraries\standard\tls\include; ..\..\..\..\..\..\modules\ports\wifi\include; ..\..\..\..\..\..\modules\libraries\standard\utils\include; ..\..\..\..\..\..\modules\libraries\standard\mqtt\include; ..\..\..\..\..\..\modules\libraries\aws\defender\include; ..\..\..\..\..\..\modules\libraries\standard\serializer\include; ..\..\..\..\..\..\modules\libraries\aws\greengrass\include; ..\..\..\..\..\..\modules\libraries\aws\shadow\include; ..\..\..\..\..\..\modules\ports\posix\include; ..\..\ports\posix; ..\..\..\..\..\..\modules\libraries\standard\freertos_plus_posix\include; ..\..\..\..\..\..\modules\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\..\modules\libraries\3rdparty\mbedtls\include\mbedtls; ..\..\..\..\..\..\modules\ports\pkcs11\mbedtls; ..\..\..\..\..\..\modules\libraries\3rdparty\pkcs11; ..\..\..\..\..\..\modules\libraries\3rdparty\tinycbor; ..\..\..\..\..\..\modules\libraries\3rdparty\jsmn
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; XIP_IMAGE; MXL12835F; IMG_BAUDRATE=96000000
  AARM.AUserIncludes: ..\common\config_files
  OBJCOPY.OOCOutputFile: aws_demos.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: XIP_IMAGE=1
  ILINK.IlinkIcfFile: LPC54018_spifi_flash_data.icf
  ILINK.IlinkAdditionalLibs: ../../../../LPC54018/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group freertos_kernel
    ../../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/include
    ../../../../../../freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group freertos_kernel/portable/MemMang
    ../../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../../freertos_kernel/portable/IAR/ARM_CM4F/: port.c portmacro.h portasm.s
  group vendors/nxp/LPC54018
    ../../../../LPC54018/: system_LPC54018.c LPC54018.h LPC54018_features.h fsl_device_registers.h system_LPC54018.h
  group vendors/nxp/LPC54018/drivers
    ../../../../LPC54018/drivers/: fsl_clock.c fsl_common.c fsl_dma.c fsl_emc.c fsl_flexcomm.c fsl_gpio.c fsl_inputmux.c fsl_pint.c fsl_power.c fsl_reset.c fsl_sha.c fsl_spi.c fsl_spi_dma.c fsl_spifi.c fsl_spifi_dma.c fsl_usart.c mflash_drv.c mflash_file.c
  group vendors/nxp/LPC54018/middleware/usb/device
    ../../../../LPC54018/middleware/usb/device/: usb_device_dci.c usb_device_lpcip3511.c usb_device.h usb_device_dci.h usb_device_lpcip3511.h
  group vendors/nxp/LPC54018/middleware/usb/osa
    ../../../../LPC54018/middleware/usb/osa/: usb_osa_freertos.c
  group vendors/nxp/LPC54018/middleware/wifi_qca
    ../../../../LPC54018/middleware/wifi_qca/: atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h qcom_api.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/api_interface
    ../../../../LPC54018/middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/bmi
    ../../../../LPC54018/middleware/wifi_qca/common_src/bmi/: bmi.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/driver
    ../../../../LPC54018/middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/hcd
    ../../../../LPC54018/middleware/wifi_qca/common_src/hcd/: spi_hcd.c hcd_api.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/htc
    ../../../../LPC54018/middleware/wifi_qca/common_src/htc/: htc.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/hw_interface
    ../../../../LPC54018/middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/qapi
    ../../../../LPC54018/middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/reorder
    ../../../../LPC54018/middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/stack_common
    ../../../../LPC54018/middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c common_stack_offload.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/storerecall
    ../../../../LPC54018/middleware/wifi_qca/common_src/storerecall/: dset.c dset_api.c storerecall.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/util
    ../../../../LPC54018/middleware/wifi_qca/common_src/util/: util.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/wmi
    ../../../../LPC54018/middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/include
    ../../../../LPC54018/middleware/wifi_qca/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/api_interface
    ../../../../LPC54018/middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/driver
    ../../../../LPC54018/middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/hw_interface
    ../../../../LPC54018/middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/qapi
    ../../../../LPC54018/middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/stack_custom
    ../../../../LPC54018/middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h qca_structs.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/include
    ../../../../LPC54018/middleware/wifi_qca/custom_src/include/: a_config.h a_osapi.h a_types.h cust_netbuf.h custom_wlan_api.h wlan_config.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port
    ../../../../LPC54018/middleware/wifi_qca/port/: wifi_common.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port/boards/lpc54018iotmodule/freertos
    ../../../../LPC54018/middleware/wifi_qca/port/boards/lpc54018iotmodule/freertos/: wifi_shield.c wifi_shield.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port/boards/lpc54018iotmodule/freertos/gt202
    ../../../../LPC54018/middleware/wifi_qca/port/boards/lpc54018iotmodule/freertos/gt202/: wifi_shield_gt202.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port/drivers/flexcomm_freertos
    ../../../../LPC54018/middleware/wifi_qca/port/drivers/flexcomm_freertos/: wifi_spi.c wifi_spi.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port/env/freertos
    ../../../../LPC54018/middleware/wifi_qca/port/env/freertos/: wifi_env.c wifi_env.h wifi_env_port.h wifi_port.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/include
    ../../../../LPC54018/middleware/wifi_qca/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h pmu.h targaddrs.h wlan_defs.h wmi.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/include/AR6002
    ../../../../LPC54018/middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/include/AR6002/hw2.0/hw
    ../../../../LPC54018/middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_apb_map.h hw20_gpio_reg.h hw20_mbox_host_reg.h hw20_mbox_reg.h hw20_rtc_reg.h hw20_si_reg.h hw20_uart_reg.h hw20_vmc_reg.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/include/AR6002/hw4.0/hw
    ../../../../LPC54018/middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_reg.h hw40_rtc_wlan_reg.h
  group vendors/nxp/LPC54018/utilities
    ../../../../LPC54018/utilities/: fsl_assert.c fsl_debug_console.c usb_device_cdc_acm.c usb_device_ch9.c usb_device_descriptor.c virtual_com.c
  group vendors/nxp/LPC54018/utilities/str
    ../../../../LPC54018/utilities/str/: fsl_str.c
  group vendors/nxp/LPC54018/utilities/log
    ../../../../LPC54018/utilities/log/: fsl_log.c
  group vendors/nxp/LPC54018/utilities/io
    ../../../../LPC54018/utilities/io/: fsl_io.c
  group vendors/nxp/LPC54018/utilities/io/swo
    ../../../../LPC54018/utilities/io/swo/: fsl_swo.c
  group vendors/nxp/LPC54018/iar
    ../../../../LPC54018/iar/: startup_LPC54018.s
  group vendors/nxp/boards/lpc54018iotmodule/ports/pkcs11
    ../../ports/pkcs11/: aws_pkcs11_pal.c hw_poll.c
  group vendors/nxp/boards/lpc54018iotmodule/ports/secure_sockets
    ../../ports/secure_sockets/: aws_secure_sockets.c
  group vendors/nxp/boards/lpc54018iotmodule/ports/wifi
    ../../ports/wifi/: aws_wifi.c
  group vendors/nxp/boards/lpc54018iotmodule/ports/posix
    ../../ports/posix/: FreeRTOS_POSIX_portable.h
  group vendors/nxp/boards/lpc54018iotmodule/aws_demos/common/application_code
    ../common/application_code/: main.c
  group vendors/nxp/boards/lpc54018iotmodule/aws_demos/common/application_code/nxp_code
    ../common/application_code/nxp_code/: board.c clock_config.c pin_mux.c wlan_qca400x.c wlan_qcom.c board.h clock_config.h pin_mux.h wlan_qcom.h
  group vendors/nxp/boards/lpc54018iotmodule/aws_demos/common/config_files
    ../common/config_files/: FreeRTOSConfig.h FreeRTOSIPConfig.h aws_bufferpool_config.h aws_demo_config.h aws_ggd_config.h aws_iot_network_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_wifi_config.h iot_config.h
  group demos/demo_runner
    ../../../../../../demos/demo_runner/: aws_demo_version.c aws_demo.c iot_demo_afr.c iot_demo_runner.c
  group demos/network_manager
    ../../../../../../demos/network_manager/: aws_iot_network_manager.c aws_iot_demo_network.c iot_network_manager_private.h
  group demos/include
    ../../../../../../demos/include/: aws_demo.h aws_clientcredential.h aws_clientcredential_keys.h aws_application_version.h iot_demo_runner.h iot_demo_logging.h iot_config_common.h aws_iot_demo_network.h
  group demos/defender
    ../../../../../../demos/defender/: aws_iot_demo_defender.c
  group demos/greengrass_connectivity
    ../../../../../../demos/greengrass_connectivity/: aws_greengrass_discovery_demo.c
  group demos/mqtt
    ../../../../../../demos/mqtt/: iot_demo_mqtt.c
  group demos/shadow
    ../../../../../../demos/shadow/: aws_iot_demo_shadow.c
  group modules/libraries/standard/provisioning/src
    ../../../../../../modules/libraries/standard/provisioning/src/: aws_dev_mode_key_provisioning.c
  group modules/libraries/standard/provisioning/include
    ../../../../../../modules/libraries/standard/provisioning/include/: aws_dev_mode_key_provisioning.h
  group modules/libraries/standard/crypto/src
    ../../../../../../modules/libraries/standard/crypto/src/: aws_crypto.c
  group modules/libraries/standard/crypto/include
    ../../../../../../modules/libraries/standard/crypto/include/: aws_crypto.h
  group modules/libraries/standard/common
    ../../../../../../modules/libraries/standard/common/: iot_init.c iot_json_utils.c
  group modules/libraries/standard/common/include
    ../../../../../../modules/libraries/standard/common/include/: aws_appversion32.h aws_json_utils.h iot_init.h iot_json_utils.h iot_linear_containers.h aws_logging_task.h iot_logging_setup.h iot_taskpool.h
  group modules/libraries/standard/common/include/private
    ../../../../../../modules/libraries/standard/common/include/private/: iot_logging.h iot_taskpool_internal.h
  group modules/libraries/standard/common/include/platform
    ../../../../../../modules/libraries/standard/common/include/platform/: iot_metrics.h iot_clock.h iot_network.h iot_network_afr.h iot_network_ble.h iot_platform_types_afr.h iot_threads.h
  group modules/libraries/standard/common/include/types
    ../../../../../../modules/libraries/standard/common/include/types/: iot_platform_types.h iot_network_types.h iot_taskpool_types.h
  group modules/libraries/standard/common/logging
    ../../../../../../modules/libraries/standard/common/logging/: aws_logging_task_dynamic_buffers.c iot_logging.c
  group modules/libraries/standard/common/platform
    ../../../../../../modules/libraries/standard/common/platform/: iot_clock_afr.c iot_network_afr.c iot_threads_afr.c
  group modules/libraries/standard/common/static_memory
    ../../../../../../modules/libraries/standard/common/static_memory/: aws_iot_static_memory_defender.c aws_iot_static_memory_shadow.c iot_static_memory_common.c iot_static_memory_metrics.c iot_static_memory_mqtt.c iot_static_memory_serializer.c iot_static_memory_taskpool.c
  group modules/libraries/standard/common/taskpool
    ../../../../../../modules/libraries/standard/common/taskpool/: iot_taskpool.c
  group modules/libraries/standard/tls/src
    ../../../../../../modules/libraries/standard/tls/src/: aws_tls.c
  group modules/libraries/standard/tls/include
    ../../../../../../modules/libraries/standard/tls/include/: aws_tls.h
  group modules/libraries/standard/utils/src
    ../../../../../../modules/libraries/standard/utils/src/: aws_system_init.c
  group modules/libraries/standard/utils/include
    ../../../../../../modules/libraries/standard/utils/include/: aws_system_init.h
  group modules/libraries/standard/metrics/src
    ../../../../../../modules/libraries/standard/metrics/src/: aws_secure_sockets_wrapper_metrics.c iot_metrics.c
  group modules/libraries/standard/mqtt/src
    ../../../../../../modules/libraries/standard/mqtt/src/: aws_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group modules/libraries/standard/serializer/src/cbor
    ../../../../../../modules/libraries/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
  group modules/libraries/standard/serializer/src/json
    ../../../../../../modules/libraries/standard/serializer/src/json/: aws_iot_serializer_json_decoder.c aws_iot_serializer_json_encoder.c
  group modules/libraries/standard/serializer/include
    ../../../../../../modules/libraries/standard/serializer/include/: iot_serializer.h
  group modules/libraries/standard/freertos_plus_posix/source
    ../../../../../../modules/libraries/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group modules/libraries/standard/freertos_plus_posix/include
    ../../../../../../modules/libraries/standard/freertos_plus_posix/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_types.h FreeRTOS_POSIX_internal.h
  group modules/libraries/standard/freertos_plus_posix/include/portable
    ../../../../../../modules/libraries/standard/freertos_plus_posix/include/portable/: FreeRTOS_POSIX_portable_default.h
  group modules/libraries/aws/defender/src
    ../../../../../../modules/libraries/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group modules/libraries/aws/defender/src/private
    ../../../../../../modules/libraries/aws/defender/src/private/: aws_iot_defender_internal.h
  group modules/libraries/aws/defender/include
    ../../../../../../modules/libraries/aws/defender/include/: aws_iot_defender.h
  group modules/libraries/aws/greengrass/src
    ../../../../../../modules/libraries/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group modules/libraries/aws/greengrass/include
    ../../../../../../modules/libraries/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group modules/libraries/aws/shadow/src
    ../../../../../../modules/libraries/aws/shadow/src/: aws_shadow.c aws_shadow_config_defaults.h aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_subscription.c
  group modules/libraries/aws/shadow/include
    ../../../../../../modules/libraries/aws/shadow/include/: aws_shadow.h aws_iot_shadow.h
  group modules/libraries/3rdparty/mbedtls/library
    ../../../../../../modules/libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group modules/libraries/3rdparty/mbedtls/include/mbedtls
    ../../../../../../modules/libraries/3rdparty/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group modules/libraries/3rdparty/pkcs11
    ../../../../../../modules/libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group modules/libraries/3rdparty/tinycbor
    ../../../../../../modules/libraries/3rdparty/tinycbor/: cborpretty.c cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c
  group modules/libraries/3rdparty/jsmn
    ../../../../../../modules/libraries/3rdparty/jsmn/: jsmn.h jsmn.c
  group modules/ports/pkcs11/include
    ../../../../../../modules/ports/pkcs11/include/: aws_pkcs11.h
  group modules/ports/pkcs11/mbedtls
    ../../../../../../modules/ports/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c threading_alt.h
  group modules/ports/secure_sockets/include
    ../../../../../../modules/ports/secure_sockets/include/: aws_secure_sockets.h aws_secure_sockets_config_defaults.h aws_secure_sockets_wrapper_metrics.h
  group modules/ports/wifi/include
    ../../../../../../modules/ports/wifi/include/: aws_wifi.h
  group modules/ports/posix/include/FreeRTOS_POSIX
    ../../../../../../modules/ports/posix/include/FreeRTOS_POSIX/: errno.h fcntl.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group modules/ports/posix/include/FreeRTOS_POSIX/sys
    ../../../../../../modules/ports/posix/include/FreeRTOS_POSIX/sys/: types.h
