# Keil uVision project aws_tests_wifi.uvproj, settings and files
target aws_tests (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: aws_tests +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MBEDTLS_USER_CONFIG_FILE=\"mbedtls_user_config.h\" UNITY_INCLUDE_CONFIG_H RVDS_ARMCM4_NUC4xx __LITTLE_ENDIAN__ AMAZON_FREERTOS_ENABLE_UNIT_TESTS M487
  c misc: --diag_suppress=550,177,C4017,111,2770,223
  c include: ..\..\..\..\..\vendors\nuvoton\sdk\Device\Nuvoton\numaker_iot_m487_wifi\Include;..\..\..\..\..\vendors\nuvoton\sdk\StdDriver\inc;..\..\..\..\..\vendors\nuvoton\sdk\CMSIS\Include;..\..\..\..\..\vendors\nuvoton\sdk\middleware\wifi_esp8266;..\..\..\..\..\libraries\abstractions\wifi\include;..\..\..\..\..\libraries\3rdparty\mbedtls\include;..\..\..\..\..\libraries\standard\utils\include;..\..\..\..\..\libraries\3rdparty\jsmn;..\..\..\..\..\libraries\3rdparty\pkcs11;..\..\..\..\..\freertos_kernel\include;..\..\..\..\..\freertos_kernel\portable\RVDS\ARM_CM4F;..\..\..\..\..\vendors\nuvoton\sdk\Device\Nuvoton\numaker_iot_m487_wifi\Include;..\..\..\..\..\vendors\nuvoton\sdk\CMSIS\Include;..\..\..\..\..\vendors\nuvoton\sdk\StdDriver\inc;..\..\..\..\..\libraries\standard\common\include;..\..\..\..\..\..\test\include;..\..\..\..\..\libraries\abstractions\pkcs11\\include;..\..\..\..\..\vendors\nuvoton\boards\numaker_iot_m487_wifi\ports\secure_sockets\include;..\..\..\..\..\libraries\aws\greengrass\include;..\..\..\..\..\libraries\c_sdk\standard\mqtt\include;..\..\..\..\..\libraries\c_sdk\standard\common\include;..\..\..\..\..\libraries\c_sdk\standard\common\include\private;..\..\..\..\..\libraries\standard\common\include\platform;..\..\..\..\..\libraries\standard\common\include\types;..\..\..\..\..\..\demos\network_manager;..\..\..\..\..\..\demos\tcp;..\..\..\..\..\vendors\nuvoton\sdk\middleware\wifi_esp8266;..\..\..\..\..\libraries\standard\crypto\include;..\..\..\..\..\libraries\3rdparty\lwip\src\include\lwip;..\..\..\..\..\libraries\aws\shadow\include;..\..\..\..\..\libraries\standard\tls\include;..\..\..\..\..\libraries\abstractions\pkcs11\\mbedtls;..\..\..\..\..\libraries\3rdparty\lwip\src\include;..\..\..\..\..\libraries\3rdparty\lwip\test\fuzz;..\..\..\..\..\libraries\3rdparty\lwip\src\portable\arch;..\..\..\..\..\libraries\3rdparty\lwip\src\portable;..\..\..\..\..\libraries\3rdparty\lwip\src\include\lwip;..\..\..\..\..\libraries\3rdparty\unity\src;..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src;..\..\..\..\..\libraries\standard\mqtt\src;..\..\..\..\..\libraries\standard\mqtt\test\access;..\..\..\..\..\libraries\aws\greengrass\src;..\..\..\..\..\vendors\nuvoton\boards\numaker_iot_m487_wifi\aws_tests\config_files\;..\..\..\..\..\vendors\nuvoton\boards\numaker_iot_m487_wifi\aws_tests\application_code\nuvoton_code;..\..\..\..\..\libraries\standard\mqtt\src\private;..\..\..\..\..\libraries\standard\freertos_plus_posix\include;..\..\..\..\..\libraries\standard\freertos_plus_posix\include\portable\nuvoton\numaker_iot_m487_wifi;..\..\..\..\..\vendors\nuvoton\boards\numaker_iot_m487_wifi\ports\posix;..\..\..\..\..\libraries\aws\shadow\src;..\..\..\..\..\libraries\aws\greengrass\test;..\..\..\..\..\libraries\c_sdk\aws\defender\include;..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\access;..\..\..\..\..\libraries\c_sdk\standard\mqtt\src;..\..\..\..\..\libraries\c_sdk\standard\serializer\include;..\..\..\..\..\libraries\c_sdk\aws\shadow\include;..\..\..\..\..\libraries\c_sdk\aws\shadow\src;..\..\..\..\..\libraries\freertos_plus\aws\greengrass\test;..\..\..\..\..\libraries\freertos_plus\aws\greengrass\include;..\..\..\..\..\libraries\freertos_plus\aws\greengrass\src;..\..\..\..\..\libraries\c_sdk\aws\defender\src\private;..\..\..\..\..\libraries\3rdparty\mbedtls\include\mbedtls;..\..\..\..\..\libraries\3rdparty\tinycbor;..\..\..\..\..\libraries\c_sdk\standard\common\include;..\..\..\..\..\libraries\c_sdk\standard\mqtt\include;..\..\..\..\..\libraries\c_sdk\standard\common\include\private;..\..\..\..\..\libraries\3rdparty\tracealyzer_recorder\Include;..\..\..\..\..\libraries\freertos_plus\standard\crypto\include;..\..\..\..\..\libraries\freertos_plus\standard\tls\include;..\..\..\..\..\libraries\freertos_plus\standard\utils\include;..\..\..\..\..\libraries\abstractions\secure_sockets\include;..\..\..\..\..\libraries\abstractions\pkcs11\include;..\..\..\..\..\libraries\abstractions\platform\include;..\..\..\..\..\libraries\abstractions\platform\freertos\include;..\..\..\..\..\libraries\abstractions\wifi\include;..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls;..\..\..\..\..\demos\dev_mode_key_provisioning\include;..\..\..\..\..\tests\include;..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_posix\include\;..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_tcp\include\;..\..\..\..\..\libraries\abstractions\posix\include\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group CMSIS
    ../../../../../vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/ARM/: startup_M480.s
    ../../../../../vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/: system_M480.c
  group User
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_tests/application_code/nuvoton_code/: entropy_hardware_poll.c
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_tests/application_code/: main.c
  group FreeRTOS
    ../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../freertos_kernel/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group NVT-Library
    ../../../../../vendors/nuvoton/sdk/StdDriver/src/: retarget.c clk.c crypto.c fmc.c sys.c uart.c
  group tests
    ../../../../../tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_afr.c iot_tests_network.c
  group wifi
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/wifi/: aws_wifi.c
    ../../../../../vendors/nuvoton/sdk/middleware/wifi_esp8266/: esp8266_wifi.c
    ../../../../../libraries/abstractions/wifi/test/: aws_test_wifi.c
  group lib-crypto
    ../../../../../libraries/freertos_plus/standard/crypto/test/: aws_test_crypto.c
    ../../../../../libraries/freertos_plus/standard/crypto/src/: aws_crypto.c
  group lib-mqtt
    ../../../../../libraries/c_sdk/standard/mqtt/test/: aws_test_mqtt_agent.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
    ../../../../../libraries/c_sdk/standard/mqtt/src/: aws_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group lib-grenngrass
    ../../../../../libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib-pkcs11
    ../../../../../libraries/abstractions/pkcs11//mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/pkcs11/: aws_pkcs11_pal.c
    ../../../../../libraries/abstractions/pkcs11/test/: aws_test_pkcs11.c
  group lib-secure_sockets
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/secure_sockets/: aws_secure_sockets.c
    ../../../../../libraries/abstractions/secure_sockets/test/: aws_test_tcp.c
  group lib-shadow
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_shadow.c aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_subscription.c
    ../../../../../libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
    ../../../../../libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
    ../../../../../libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
  group lib-tls
    ../../../../../libraries/freertos_plus/standard/tls/src/: aws_tls.c
    ../../../../../libraries/freertos_plus/standard/tls/test/: aws_test_tls.c
  group lib-utils
    ../../../../../libraries/freertos_plus/standard/utils/src/: aws_system_init.c
  group 3rd-jsmn
    ../../../../../libraries/3rdparty/jsmn/: jsmn.c
  group 3rd-mbedtls
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c platform_util.c
  group modules/libraries/standard/common
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_afr.c iot_network_afr.c iot_threads_afr.c
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c
    ../../../../../libraries/c_sdk/standard/common/: iot_init.c
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_json_utils.c
    ../../../../../libraries/c_sdk/standard/common/logging/: iot_logging.c aws_logging_task_dynamic_buffers.c
    ../../../../../libraries/c_sdk/standard/common/test/: aws_memory_leak.c iot_tests_taskpool.c
    ../../../../../libraries/abstractions/platform/test/: iot_test_platform_clock.c iot_test_platform_threads.c
  group 3rd-unity
    ../../../../../libraries/3rdparty/unity/src/: unity.c
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group FreeRTOS-test
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/test/: aws_test_posix_clock.c aws_test_posix_mqueue.c aws_test_posix_pthread.c aws_test_posix_semaphore.c aws_test_posix_stress.c aws_test_posix_timer.c aws_test_posix_unistd.c aws_test_posix_utils.c
  group FreeRTOS-source
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group lib-std-metrics
    ../../../../../libraries/abstractions/platform/freertos/: iot_metrics.c
  group lib-std-provisioning
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c pem2der.c
