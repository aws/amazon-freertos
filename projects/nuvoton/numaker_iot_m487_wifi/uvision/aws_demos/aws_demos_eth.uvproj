# Keil uVision project aws_demos_eth.uvproj, settings and files
target aws_demos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: aws_demos +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx __little_endian__=1 NDEBUG M487_ETH_DEMO
  c misc: --diag_suppress=550,177,C4017,111,2770,223
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
