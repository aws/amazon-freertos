# Keil uVision project aws_demos.uvproj, settings and files
target aws_demos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: aws_demos +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MBEDTLS_CONFIG_FILE="<aws_mbedtls_config.h>" CONFIG_MEDTLS_USE_AFR_MEMORY RVDS_ARMCM4_NUC4xx __little_endian__=1 NDEBUG
  c misc: --diag_suppress=550,177,C4017,111,2770,223
  c include: ../../../../../freertos_kernel/include;../../../../../freertos_kernel/portable/RVDS/ARM_CM4F;../../../../../vendors/nuvoton/sdk/CMSIS/Include;../../../../../vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Include;../../../../../vendors/nuvoton/sdk/middleware/wifi_esp8266;../../../../../vendors/nuvoton/sdk/StdDriver/inc;../../../../../libraries/freertos_plus/standard/crypto/include;../../../../../libraries/freertos_plus/standard/freertos_plus_tcp/include;../../../../../libraries/freertos_plus/standard/freertos_plus_tcp/portable/Compiler/Keil;../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_demos/config_files;../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_demos/application_code/nuvoton_code;../../../../../demos/include;../../../../../demos/network_manager;../../../../../libraries/c_sdk/standard/common/include/private;../../../../../libraries/c_sdk/standard/common/include;../../../../../libraries/abstractions/platform/include;../../../../../libraries/abstractions/platform/freertos/include;../../../../../libraries/abstractions/platform/include/platform;../../../../../libraries/abstractions/secure_sockets/include;../../../../../libraries/freertos_plus/standard/tls/include;../../../../../libraries/abstractions/pkcs11/corePKCS11/source/include;../../../../../libraries/freertos_plus/standard/utils/include;../../../../../libraries/abstractions/wifi/include;../../../../../libraries/logging/include;../../../../../demos/dev_mode_key_provisioning/include;../../../../../libraries/c_sdk/aws/defender/include;../../../../../libraries/c_sdk/standard/mqtt/include;../../../../../libraries/coreMQTT/source/include;../../../../../libraries/coreMQTT/source/interface;../../../../../libraries/abstractions/backoff_algorithm/source/include;../../../../../demos/common/pkcs11_helpers;../../../../../libraries/abstractions/transport/secure_sockets;../../../../../libraries/c_sdk/standard/serializer/include;../../../../../libraries/c_sdk/aws/shadow/include;../../../../../libraries/c_sdk/standard/https/include;../../../../../libraries/coreHTTP/source/include;../../../../../libraries/coreHTTP/source/interface;../../../../../libraries/coreHTTP/source/dependency/3rdparty/http_parser;../../../../../demos/common/http_demo_helpers;../../../../../libraries/freertos_plus/aws/greengrass/include;../../../../../libraries/freertos_plus/standard/freertos_plus_cli/include;../../../../../libraries/coreMQTT-Agent/source/include;../../../../../demos/common/mqtt_subscription_manager;../../../../../libraries/abstractions/mqtt_agent/include;../../../../../libraries/abstractions/mqtt_agent;../../../../../libraries/coreJSON/source/include;../../../../../libraries/device_shadow_for_aws/source/include;../../../../../demos/common/mqtt_demo_helpers;../../../../../libraries/device_defender_for_aws/source/include;../../../../../libraries/jobs_for_aws/source/include;../../../../../demos/coreMQTT_Agent;../../../../../demos/device_defender_for_aws;../../../../../libraries/3rdparty/pkcs11;../../../../../libraries/3rdparty/mbedtls/include;../../../../../libraries/3rdparty/mbedtls_config;../../../../../libraries/3rdparty/mbedtls/include/mbedtls;../../../../../libraries/3rdparty/mbedtls_utils;../../../../../libraries/3rdparty/tinycbor/src;../../../../../libraries/3rdparty/jsmn
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group freertos_kernel/
    ../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/include/
    ../../../../../freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group vendors/nuvoton/sdk/StdDriver/src/
    ../../../../../vendors/nuvoton/sdk/StdDriver/src/: clk.c crypto.c fmc.c sys.c uart.c retarget.c gpio.c spim.c
  group freertos_kernel/portable/MemMang/
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group freertos_kernel/portable/RVDS/ARM_CM4F/
    ../../../../../freertos_kernel/portable/RVDS/ARM_CM4F/: port.c
  group vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_demos/application_code/nuvoton_code/
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_demos/application_code/nuvoton_code/: entropy_hardware_poll.c
  group demos/demo_runner/
    ../../../../../demos/demo_runner/: aws_demo.c iot_demo_freertos.c iot_demo_runner.c
  group demos/network_manager/
    ../../../../../demos/network_manager/: aws_iot_network_manager.c aws_iot_demo_network.c iot_network_manager_private.h
  group demos/include/
    ../../../../../demos/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_iot_demo_network.h aws_ota_codesigner_certificate.h iot_config_common.h iot_demo_logging.h iot_demo_runner.h aws_iot_metrics.h
  group libraries/c_sdk/standard/common/
    ../../../../../libraries/c_sdk/standard/common/: iot_init.c iot_static_memory_common.c iot_device_metrics.c
  group libraries/c_sdk/standard/common/include/
    ../../../../../libraries/c_sdk/standard/common/include/: iot_init.h iot_linear_containers.h iot_taskpool.h
  group libraries/c_sdk/standard/common/include/types/
    ../../../../../libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group libraries/c_sdk/standard/common/taskpool/
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/c_sdk/standard/common/include/private/
    ../../../../../libraries/c_sdk/standard/common/include/private/: iot_taskpool_internal.h
  group libraries/abstractions/platform/include/platform/
    ../../../../../libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h iot_metrics.h
  group libraries/abstractions/platform/include/types/
    ../../../../../libraries/abstractions/platform/include/types/: iot_platform_types.h
  group libraries/abstractions/platform/freertos/
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_threads_freertos.c iot_metrics.c iot_network_freertos.c
  group libraries/abstractions/platform/freertos/include/platform/
    ../../../../../libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_freertos.h iot_network_freertos.h
  group libraries/abstractions/secure_sockets/include/
    ../../../../../libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/secure_sockets/
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/secure_sockets/: iot_secure_sockets.c
  group libraries/freertos_plus/standard/tls/src/
    ../../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group libraries/freertos_plus/standard/tls/include/
    ../../../../../libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group libraries/freertos_plus/standard/crypto/src/
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/crypto/include/
    ../../../../../libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group libraries/abstractions/pkcs11/corePKCS11/source/include/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/include/: core_pkcs11.h core_pkcs11_pal.h core_pki_utils.h
  group libraries/abstractions/pkcs11/corePKCS11/source/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
  group vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/pkcs11/
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/pkcs11/: core_pkcs11_pal.c
  group libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group libraries/3rdparty/mbedtls_config/
    ../../../../../libraries/3rdparty/mbedtls_config/: threading_alt.h
  group libraries/freertos_plus/standard/utils/src/
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group libraries/freertos_plus/standard/utils/include/
    ../../../../../libraries/freertos_plus/standard/utils/include/: iot_system_init.h
  group libraries/abstractions/wifi/include/
    ../../../../../libraries/abstractions/wifi/include/: iot_wifi.h
  group vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/wifi/
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/ports/wifi/: iot_wifi.c
  group vendors/nuvoton/sdk/middleware/wifi_esp8266/
    ../../../../../vendors/nuvoton/sdk/middleware/wifi_esp8266/: esp8266_wifi.c
  group libraries/logging/
    ../../../../../libraries/logging/: iot_logging_task_dynamic_buffers.c iot_logging.c
  group libraries/logging/include/
    ../../../../../libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
  group demos/dev_mode_key_provisioning/src/
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group demos/dev_mode_key_provisioning/include/
    ../../../../../demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group libraries/c_sdk/aws/defender/src/
    ../../../../../libraries/c_sdk/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group libraries/c_sdk/aws/defender/src/private/
    ../../../../../libraries/c_sdk/aws/defender/src/private/: aws_iot_defender_internal.h
  group libraries/c_sdk/aws/defender/include/
    ../../../../../libraries/c_sdk/aws/defender/include/: aws_iot_defender.h
  group libraries/c_sdk/standard/mqtt/src/
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c iot_mqtt_context_connection.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_managed_function_wrapper.c iot_mqtt_subscription_container.c iot_mqtt_mutex_wrapper.c iot_mqtt_agent.c
  group libraries/coreMQTT/source/
    ../../../../../libraries/coreMQTT/source/: core_mqtt.c core_mqtt_state.c core_mqtt_serializer.c
  group libraries/coreMQTT/source/include/
    ../../../../../libraries/coreMQTT/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_serializer.h core_mqtt_state.h
  group libraries/coreMQTT/source/interface/
    ../../../../../libraries/coreMQTT/source/interface/: transport_interface.h
  group libraries/abstractions/backoff_algorithm/source/
    ../../../../../libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
  group libraries/abstractions/backoff_algorithm/source/include/
    ../../../../../libraries/abstractions/backoff_algorithm/source/include/: backoff_algorithm.h
  group demos/common/pkcs11_helpers/
    ../../../../../demos/common/pkcs11_helpers/: pkcs11_helpers.c
  group libraries/abstractions/transport/secure_sockets/
    ../../../../../libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.h transport_secure_sockets.c
  group libraries/c_sdk/standard/serializer/src/cbor/
    ../../../../../libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
  group libraries/c_sdk/standard/serializer/src/json/
    ../../../../../libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group libraries/c_sdk/standard/serializer/src/
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_serializer_static_memory.c iot_json_utils.c
  group libraries/c_sdk/standard/serializer/include/
    ../../../../../libraries/c_sdk/standard/serializer/include/: iot_serializer.h iot_json_utils.h
  group libraries/c_sdk/aws/shadow/src/
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group libraries/c_sdk/aws/shadow/include/
    ../../../../../libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group libraries/c_sdk/standard/https/src/
    ../../../../../libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group libraries/coreHTTP/source/
    ../../../../../libraries/coreHTTP/source/: core_http_client.c
  group libraries/coreHTTP/source/dependency/3rdparty/http_parser/
    ../../../../../libraries/coreHTTP/source/dependency/3rdparty/http_parser/: http_parser.c http_parser.h
  group libraries/coreHTTP/source/include/
    ../../../../../libraries/coreHTTP/source/include/: core_http_client.h core_http_client_private.h core_http_config_defaults.h
  group libraries/coreHTTP/source/interface/
    ../../../../../libraries/coreHTTP/source/interface/: transport_interface.h
  group demos/common/http_demo_helpers/
    ../../../../../demos/common/http_demo_helpers/: http_demo_utils.c
  group libraries/freertos_plus/aws/greengrass/src/
    ../../../../../libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group libraries/freertos_plus/aws/greengrass/include/
    ../../../../../libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group libraries/freertos_plus/standard/freertos_plus_cli/source/
    ../../../../../libraries/freertos_plus/standard/freertos_plus_cli/source/: FreeRTOS_CLI.c FreeRTOS_CLI_Console.c
  group libraries/coreMQTT-Agent/source/
    ../../../../../libraries/coreMQTT-Agent/source/: core_mqtt_agent.c core_mqtt_agent_command_functions.c
  group libraries/coreMQTT-Agent/source/include/
    ../../../../../libraries/coreMQTT-Agent/source/include/: core_mqtt_agent.h core_mqtt_agent_command_functions.h core_mqtt_agent_message_interface.h
  group demos/common/mqtt_subscription_manager/
    ../../../../../demos/common/mqtt_subscription_manager/: subscription_manager.c
  group libraries/abstractions/mqtt_agent/
    ../../../../../libraries/abstractions/mqtt_agent/: freertos_agent_message.c freertos_command_pool.c
  group libraries/coreJSON/source/
    ../../../../../libraries/coreJSON/source/: core_json.c
  group libraries/coreJSON/source/include/
    ../../../../../libraries/coreJSON/source/include/: core_json.h
  group libraries/device_shadow_for_aws/source/
    ../../../../../libraries/device_shadow_for_aws/source/: shadow.c
  group libraries/device_shadow_for_aws/source/include/
    ../../../../../libraries/device_shadow_for_aws/source/include/: shadow.h shadow_config_defaults.h
  group demos/common/mqtt_demo_helpers/
    ../../../../../demos/common/mqtt_demo_helpers/: mqtt_demo_helpers.c
  group libraries/device_defender_for_aws/source/
    ../../../../../libraries/device_defender_for_aws/source/: defender.c
  group libraries/device_defender_for_aws/source/include/
    ../../../../../libraries/device_defender_for_aws/source/include/: defender.h defender_config_defaults.h
  group libraries/jobs_for_aws/source/
    ../../../../../libraries/jobs_for_aws/source/: jobs.c
  group libraries/jobs_for_aws/source/include/
    ../../../../../libraries/jobs_for_aws/source/include/: jobs.h
  group demos/coreHTTP/
    ../../../../../demos/coreHTTP/: http_demo_mutual_auth.c http_demo_s3_download.c http_demo_s3_download_multithreaded.c http_demo_s3_upload.c
  group demos/coreMQTT/
    ../../../../../demos/coreMQTT/: mqtt_demo_mutual_auth.c
  group demos/coreMQTT_Agent/
    ../../../../../demos/coreMQTT_Agent/: mqtt_agent_task.c simple_sub_pub_demo.c
  group demos/device_defender_for_aws/
    ../../../../../demos/device_defender_for_aws/: defender_demo.c report_builder.c report_builder.h metrics_collector.h
  group demos/device_defender_for_aws/metrics_collector/stub/
    ../../../../../demos/device_defender_for_aws/metrics_collector/stub/: metrics_collector.c
  group demos/device_shadow_for_aws/
    ../../../../../demos/device_shadow_for_aws/: shadow_demo_main.c
  group demos/greengrass_connectivity/
    ../../../../../demos/greengrass_connectivity/: aws_greengrass_discovery_demo.c
  group demos/jobs_for_aws/
    ../../../../../demos/jobs_for_aws/: jobs_demo.c
  group demos/tcp/
    ../../../../../demos/tcp/: aws_tcp_echo_client_single_task.c aws_tcp_echo_client_single_tasks.h
  group vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_demos/config_files/
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_demos/config_files/: FreeRTOSConfig.h FreeRTOSIPConfig.h aws_demo_config.h aws_ggd_config.h aws_iot_network_config.h aws_ota_agent_config.h aws_shadow_config.h aws_wifi_config.h core_http_config.h core_mqtt_config.h core_pkcs11_config.h defender_config.h defender_demo_config.h http_demo_mutual_auth_config.h http_demo_s3_download_config.h http_demo_s3_download_multithreaded_config.h http_demo_s3_upload_config.h iot_bufferpool_config.h iot_config.h iot_mqtt_agent_config.h iot_mqtt_config.h iot_secure_sockets_config.h jobs_demo_config.h mqtt_agent_demo_config.h mqtt_demo_mutual_auth_config.h mqtt_demo_plaintext_config.h shadow_config.h shadow_demo_config.h
  group vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_demos/application_code/
    ../../../../../vendors/nuvoton/boards/numaker_iot_m487_wifi/aws_demos/application_code/: main.c
  group vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/ARM/
    ../../../../../vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/ARM/: startup_M480.s
  group vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/
    ../../../../../vendors/nuvoton/sdk/Device/Nuvoton/numaker_iot_m487_wifi/Source/: system_M480.c
  group libraries/3rdparty/mbedtls/library/
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libraries/3rdparty/mbedtls/include/mbedtls/
    ../../../../../libraries/3rdparty/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group libraries/3rdparty/mbedtls_utils/
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_utils.c mbedtls_error.h mbedtls_error.c
  group libraries/3rdparty/pkcs11/
    ../../../../../libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group libraries/3rdparty/tinycbor/src/
    ../../../../../libraries/3rdparty/tinycbor/src/: cborpretty.c cborpretty_stdio.c cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c
  group libraries/3rdparty/jsmn/
    ../../../../../libraries/3rdparty/jsmn/: jsmn.h jsmn.c
