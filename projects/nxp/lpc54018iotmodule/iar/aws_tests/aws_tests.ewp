# IAR project aws_tests.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54018 NXP LPC54018
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; CONFIG_MEDTLS_USE_AFR_MEMORY; DEBUG; XIP_IMAGE; CPU_LPC54018; SDK_DEBUGCONSOLE=1; USB_STACK_FREERTOS; USB_STACK_USE_DEDICATED_RAM=1; CPU_LPC54018JET180=1; USE_RTOS=1; FSL_RTOS_FREE_RTOS; A_LITTLE_ENDIAN; FREERTOS_ENABLE_UNIT_TESTS; UNITY_INCLUDE_CONFIG_H; _DLIB_FILE_DESCRIPTOR=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe513
  ICCARM.CCIncludePath2: ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\vendors\nxp\LPC54018; ..\..\..\..\..\vendors\nxp\LPC54018\drivers; ..\..\..\..\..\vendors\nxp\LPC54018\cmsis_drivers; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\common_src\hcd; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\common_src\include; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\common_src\stack_common; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\common_src\wmi; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\custom_src\include; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\custom_src\stack_custom; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\include; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\include\AR6002; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\include\AR6002\hw2.0\hw; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\port; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos\gt202; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\port\drivers\flexcomm_freertos; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\port\env\freertos; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\usb\device; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\usb\include; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\usb\osa; ..\..\..\..\..\vendors\nxp\LPC54018\utilities; ..\..\..\..\..\vendors\nxp\LPC54018\utilities\io; ..\..\..\..\..\vendors\nxp\LPC54018\utilities\log; ..\..\..\..\..\vendors\nxp\LPC54018\utilities\str; ..\..\..\..\..\vendors\nxp\LPC54018\CMSIS\Include; ..\..\..\..\..\vendors\nxp\boards\lpc54018iotmodule\aws_tests\config_files; ..\..\..\..\..\vendors\nxp\boards\lpc54018iotmodule\aws_tests\application_code\nxp_code; ..\..\..\..\..\tests\include; ..\..\..\..\..\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\..\..\..\libraries\c_sdk\standard\common\include\private; ..\..\..\..\..\libraries\c_sdk\standard\common\include; ..\..\..\..\..\libraries\abstractions\platform\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include; ..\..\..\..\..\libraries\abstractions\platform\include\platform; ..\..\..\..\..\libraries\logging\include; ..\..\..\..\..\demos\dev_mode_key_provisioning\include; ..\..\..\..\..\libraries\abstractions\pkcs11\corePKCS11\source\include; ..\..\..\..\..\libraries\freertos_plus\standard\crypto\include; ..\..\..\..\..\libraries\freertos_plus\standard\utils\include; ..\..\..\..\..\libraries\abstractions\secure_sockets\include; ..\..\..\..\..\libraries\freertos_plus\standard\tls\include; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\libraries\freertos_plus\aws\greengrass\test; ..\..\..\..\..\libraries\freertos_plus\aws\greengrass\include; ..\..\..\..\..\libraries\freertos_plus\aws\greengrass\src; ..\..\..\..\..\libraries\coreMQTT\source\include; ..\..\..\..\..\libraries\coreMQTT\source\interface; ..\..\..\..\..\libraries\abstractions\backoff_algorithm\source\include; ..\..\..\..\..\demos\common\pkcs11_helpers; ..\..\..\..\..\libraries\abstractions\transport\secure_sockets; ..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_cli\include; ..\..\..\..\..\libraries\abstractions\posix\include; ..\..\..\..\..\vendors\nxp\boards\lpc54018iotmodule\ports\posix; ..\..\..\..\..\libraries\freertos_plus\standard\freertos_plus_posix\include; ..\..\..\..\..\libraries\coreMQTT-Agent\source\include; ..\..\..\..\..\libraries\abstractions\mqtt_agent\include; ..\..\..\..\..\libraries\abstractions\mqtt_agent; ..\..\..\..\..\libraries\coreHTTP\source\include; ..\..\..\..\..\libraries\coreHTTP\source\interface; ..\..\..\..\..\libraries\coreHTTP\source\dependency\3rdparty\llhttp\include; ..\..\..\..\..\demos\common\http_demo_helpers; ..\..\..\..\..\libraries\coreJSON\source\include; ..\..\..\..\..\libraries\device_shadow_for_aws\source\include; ..\..\..\..\..\demos\common\mqtt_demo_helpers; ..\..\..\..\..\demos\include; ..\..\..\..\..\libraries\device_defender_for_aws\source\include; ..\..\..\..\..\libraries\jobs_for_aws\source\include; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\..\..\libraries\3rdparty\pkcs11; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\libraries\3rdparty\mbedtls_config; ..\..\..\..\..\libraries\3rdparty\mbedtls\include\mbedtls; ..\..\..\..\..\libraries\3rdparty\mbedtls\library; ..\..\..\..\..\libraries\3rdparty\mbedtls_utils; ..\..\..\..\..\libraries\3rdparty\jsmn
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; XIP_IMAGE; MXL12835F; IMG_BAUDRATE=96000000
  AARM.AUserIncludes: ../../../../../vendors/nxp/boards/lpc54018iotmodule/aws_tests/config_files
  OBJCOPY.OOCOutputFile: aws_tests.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: XIP_IMAGE=1
  ILINK.IlinkIcfFile: ../../../../../vendors/nxp/LPC54018/iar/LPC54018_spifi_flash_data.icf
  ILINK.IlinkAdditionalLibs: ../../../../../vendors/nxp/LPC54018/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group freertos_kernel
    ../../../../../freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/include
    ../../../../../freertos_kernel/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group freertos_kernel/portable/MemMang
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../freertos_kernel/portable/IAR/ARM_CM4F/: port.c portmacro.h portasm.s
  group vendors/nxp/LPC54018
    ../../../../../vendors/nxp/LPC54018/: system_LPC54018.c LPC54018.h LPC54018_features.h fsl_device_registers.h system_LPC54018.h
  group vendors/nxp/LPC54018/drivers
    ../../../../../vendors/nxp/LPC54018/drivers/: fsl_clock.c fsl_common.c fsl_dma.c fsl_emc.c fsl_flexcomm.c fsl_gpio.c fsl_inputmux.c fsl_pint.c fsl_power.c fsl_reset.c fsl_sha.c fsl_spi.c fsl_spi_dma.c fsl_spifi.c fsl_spifi_dma.c fsl_usart.c mflash_drv.c mflash_file.c
  group vendors/nxp/LPC54018/middleware/usb/device
    ../../../../../vendors/nxp/LPC54018/middleware/usb/device/: usb_device_dci.c usb_device_lpcip3511.c usb_device.h usb_device_dci.h usb_device_lpcip3511.h
  group vendors/nxp/LPC54018/middleware/usb/osa
    ../../../../../vendors/nxp/LPC54018/middleware/usb/osa/: usb_osa_freertos.c
  group vendors/nxp/LPC54018/middleware/wifi_qca
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/: atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h qcom_api.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/api_interface
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/bmi
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/bmi/: bmi.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/driver
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/hcd
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/hcd/: spi_hcd.c hcd_api.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/htc
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/htc/: htc.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/hw_interface
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/hw_interface/: hw_api.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/qapi
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/qapi/: qcom_api.c qcom_dns.c qcom_legacy.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/reorder
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/reorder/: rcv_aggr.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/stack_common
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/stack_common/: api_stack_offload.c common_stack_offload.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/storerecall
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/storerecall/: dset.c dset_api.c storerecall.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/util
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/util/: util.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/wmi
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/wmi/: wmi.c wmi_host.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/common_src/include
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/api_interface
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/driver
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/hw_interface
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/hw_interface/: cust_spi_hcd.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/qapi
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/qapi/: custom_qcom_api.c
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/stack_custom
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h qca_structs.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/include
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/custom_src/include/: a_config.h a_osapi.h a_types.h cust_netbuf.h custom_wlan_api.h wlan_config.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/port/: wifi_common.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port/boards/lpc54018iotmodule/freertos
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/port/boards/lpc54018iotmodule/freertos/: wifi_shield.c wifi_shield.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port/boards/lpc54018iotmodule/freertos/gt202
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/port/boards/lpc54018iotmodule/freertos/gt202/: wifi_shield_gt202.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port/drivers/flexcomm_freertos
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/port/drivers/flexcomm_freertos/: wifi_spi.c wifi_spi.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/port/env/freertos
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/port/env/freertos/: wifi_env.c wifi_env.h wifi_env_port.h wifi_port.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/include
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h pmu.h targaddrs.h wlan_defs.h wmi.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/include/AR6002
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/include/AR6002/: AR6K_version.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/include/AR6002/hw2.0/hw
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/include/AR6002/hw2.0/hw/: hw20_apb_map.h hw20_gpio_reg.h hw20_mbox_host_reg.h hw20_mbox_reg.h hw20_rtc_reg.h hw20_si_reg.h hw20_uart_reg.h hw20_vmc_reg.h
  group vendors/nxp/LPC54018/middleware/wifi_qca/include/AR6002/hw4.0/hw
    ../../../../../vendors/nxp/LPC54018/middleware/wifi_qca/include/AR6002/hw4.0/hw/: hw40_rtc_reg.h hw40_rtc_wlan_reg.h
  group vendors/nxp/LPC54018/utilities
    ../../../../../vendors/nxp/LPC54018/utilities/: fsl_assert.c fsl_debug_console.c usb_device_cdc_acm.c usb_device_ch9.c usb_device_descriptor.c virtual_com.c
  group vendors/nxp/LPC54018/utilities/str
    ../../../../../vendors/nxp/LPC54018/utilities/str/: fsl_str.c
  group vendors/nxp/LPC54018/utilities/log
    ../../../../../vendors/nxp/LPC54018/utilities/log/: fsl_log.c
  group vendors/nxp/LPC54018/utilities/io
    ../../../../../vendors/nxp/LPC54018/utilities/io/: fsl_io.c
  group vendors/nxp/LPC54018/utilities/io/swo
    ../../../../../vendors/nxp/LPC54018/utilities/io/swo/: fsl_swo.c
  group vendors/nxp/LPC54018/iar
    ../../../../../vendors/nxp/LPC54018/iar/: startup_LPC54018.s
  group vendors/nxp/boards/lpc54018iotmodule/ports/pkcs11
    ../../../../../vendors/nxp/boards/lpc54018iotmodule/ports/pkcs11/: core_pkcs11_pal.c hw_poll.c
  group vendors/nxp/boards/lpc54018iotmodule/ports/secure_sockets
    ../../../../../vendors/nxp/boards/lpc54018iotmodule/ports/secure_sockets/: iot_secure_sockets.c
  group vendors/nxp/boards/lpc54018iotmodule/ports/wifi
    ../../../../../vendors/nxp/boards/lpc54018iotmodule/ports/wifi/: iot_wifi.c
  group vendors/nxp/boards/lpc54018iotmodule/ports/posix
    ../../../../../vendors/nxp/boards/lpc54018iotmodule/ports/posix/: FreeRTOS_POSIX_portable.h
  group vendors/nxp/boards/lpc54018iotmodule/aws_tests/application_code
    ../../../../../vendors/nxp/boards/lpc54018iotmodule/aws_tests/application_code/: main.c
  group vendors/nxp/boards/lpc54018iotmodule/aws_tests/application_code/nxp_code
    ../../../../../vendors/nxp/boards/lpc54018iotmodule/aws_tests/application_code/nxp_code/: board.c clock_config.c pin_mux.c board.h clock_config.h pin_mux.h
  group vendors/nxp/boards/lpc54018iotmodule/aws_tests/config_files
    ../../../../../vendors/nxp/boards/lpc54018iotmodule/aws_tests/config_files/: FreeRTOSConfig.h FreeRTOSIPConfig.h aws_ggd_config.h aws_shadow_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h core_http_config.h core_mqtt_config.h core_pkcs11_config.h core_test_pkcs11_config.h defender_config.h iot_bufferpool_config.h iot_config.h iot_mqtt_agent_config.h iot_mqtt_config.h iot_secure_sockets_config.h shadow_config.h unity_config.h
  group tests/common
    ../../../../../tests/common/: aws_test_framework.c aws_test_runner.c aws_test.c iot_test_freertos.c iot_tests_network.c
  group tests/include
    ../../../../../tests/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_test_runner.h aws_test_framework.h aws_test_tcp.h aws_test_utils.h aws_unity_config.h iot_config_common.h
  group tests/integration_test
    ../../../../../tests/integration_test/: core_mqtt_system_test.c shadow_system_test.c core_http_system_test.c
  group libraries/c_sdk/standard/common
    ../../../../../libraries/c_sdk/standard/common/: iot_init.c iot_static_memory_common.c iot_device_metrics.c
  group libraries/c_sdk/standard/common/include
    ../../../../../libraries/c_sdk/standard/common/include/: iot_init.h iot_linear_containers.h iot_taskpool.h
  group libraries/c_sdk/standard/common/include/types
    ../../../../../libraries/c_sdk/standard/common/include/types/: iot_taskpool_types.h
  group libraries/c_sdk/standard/common/include/private
    ../../../../../libraries/c_sdk/standard/common/include/private/: iot_taskpool_internal.h
  group libraries/c_sdk/standard/common/taskpool
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/c_sdk/standard/common/test
    ../../../../../libraries/c_sdk/standard/common/test/: iot_memory_leak.c iot_tests_taskpool.c
  group libraries/abstractions/platform/include/platform
    ../../../../../libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h
  group libraries/abstractions/platform/include/types
    ../../../../../libraries/abstractions/platform/include/types/: iot_platform_types.h iot_network_types.h
  group libraries/abstractions/platform/freertos
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_threads_freertos.c
  group libraries/abstractions/platform/freertos/include/platform
    ../../../../../libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_freertos.h
  group libraries/abstractions/platform/test
    ../../../../../libraries/abstractions/platform/test/: iot_test_platform_clock.c iot_test_platform_threads.c
  group libraries/abstractions/pkcs11/corePKCS11/source
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
  group libraries/abstractions/pkcs11/corePKCS11/source/include
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/include/: core_pkcs11.h core_pkcs11_pal.h core_pki_utils.h
  group libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group libraries/abstractions/pkcs11/test
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
  group libraries/abstractions/secure_sockets/include
    ../../../../../libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h
  group libraries/abstractions/secure_sockets/test
    ../../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
  group libraries/abstractions/wifi/include
    ../../../../../libraries/abstractions/wifi/include/: iot_wifi.h
  group libraries/abstractions/wifi/test
    ../../../../../libraries/abstractions/wifi/test/: iot_test_wifi.c
  group libraries/abstractions/backoff_algorithm/source
    ../../../../../libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
  group libraries/abstractions/backoff_algorithm/source/include
    ../../../../../libraries/abstractions/backoff_algorithm/source/include/: backoff_algorithm.h
  group libraries/abstractions/transport/secure_sockets
    ../../../../../libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.h transport_secure_sockets.c
  group libraries/abstractions/posix/include/FreeRTOS_POSIX
    ../../../../../libraries/abstractions/posix/include/FreeRTOS_POSIX/: errno.h fcntl.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group libraries/abstractions/posix/include/FreeRTOS_POSIX/sys
    ../../../../../libraries/abstractions/posix/include/FreeRTOS_POSIX/sys/: types.h
  group libraries/abstractions/mqtt_agent
    ../../../../../libraries/abstractions/mqtt_agent/: freertos_agent_message.c freertos_command_pool.c
  group libraries/abstractions/mqtt_agent/include
    ../../../../../libraries/abstractions/mqtt_agent/include/: freertos_agent_message.h freertos_command_pool.h
  group libraries/logging
    ../../../../../libraries/logging/: iot_logging_task_dynamic_buffers.c iot_logging.c
  group libraries/logging/include
    ../../../../../libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
  group libraries/3rdparty/mbedtls_config
    ../../../../../libraries/3rdparty/mbedtls_config/: threading_alt.h
  group libraries/3rdparty/unity/src
    ../../../../../libraries/3rdparty/unity/src/: unity.c unity.h unity_internals.h
  group libraries/3rdparty/unity/extras/fixture/src
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group libraries/3rdparty/mbedtls/library
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libraries/3rdparty/mbedtls/include/mbedtls
    ../../../../../libraries/3rdparty/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group libraries/3rdparty/mbedtls_utils
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_utils.c mbedtls_error.h mbedtls_error.c
  group libraries/3rdparty/pkcs11
    ../../../../../libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group libraries/3rdparty/jsmn
    ../../../../../libraries/3rdparty/jsmn/: jsmn.h jsmn.c
  group libraries/freertos_plus/standard/crypto/src
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/crypto/include
    ../../../../../libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group libraries/freertos_plus/standard/crypto/test
    ../../../../../libraries/freertos_plus/standard/crypto/test/: iot_test_crypto.c
  group libraries/freertos_plus/standard/utils/src
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group libraries/freertos_plus/standard/utils/include
    ../../../../../libraries/freertos_plus/standard/utils/include/: iot_system_init.h
  group libraries/freertos_plus/standard/tls/src
    ../../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group libraries/freertos_plus/standard/tls/include
    ../../../../../libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group libraries/freertos_plus/standard/tls/test
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
  group libraries/freertos_plus/standard/freertos_plus_cli/source
    ../../../../../libraries/freertos_plus/standard/freertos_plus_cli/source/: FreeRTOS_CLI.c FreeRTOS_CLI_Console.c
  group libraries/freertos_plus/standard/freertos_plus_cli/utest
    ../../../../../libraries/freertos_plus/standard/freertos_plus_cli/utest/: iot_test_freertos_cli.c iot_test_freertos_cli_console.c
  group libraries/freertos_plus/standard/freertos_plus_posix/source
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group libraries/freertos_plus/standard/freertos_plus_posix/include
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_types.h FreeRTOS_POSIX_internal.h FreeRTOS_POSIX_portable_default.h
  group libraries/freertos_plus/standard/freertos_plus_posix/test
    ../../../../../libraries/freertos_plus/standard/freertos_plus_posix/test/: iot_test_posix_clock.c iot_test_posix_mqueue.c iot_test_posix_pthread.c iot_test_posix_semaphore.c iot_test_posix_stress.c iot_test_posix_timer.c iot_test_posix_unistd.c iot_test_posix_utils.c
  group libraries/freertos_plus/aws/greengrass/src
    ../../../../../libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group libraries/freertos_plus/aws/greengrass/include
    ../../../../../libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group libraries/freertos_plus/aws/greengrass/test
    ../../../../../libraries/freertos_plus/aws/greengrass/test/: aws_test_ggd_system.c aws_test_ggd_unit.c aws_test_helper_secure_connect.c
  group libraries/coreMQTT/source
    ../../../../../libraries/coreMQTT/source/: core_mqtt.c core_mqtt_state.c core_mqtt_serializer.c
  group libraries/coreMQTT/source/include
    ../../../../../libraries/coreMQTT/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_serializer.h core_mqtt_state.h
  group libraries/coreMQTT/source/interface
    ../../../../../libraries/coreMQTT/source/interface/: transport_interface.h
  group libraries/coreMQTT-Agent/source
    ../../../../../libraries/coreMQTT-Agent/source/: core_mqtt_agent.c core_mqtt_agent_command_functions.c
  group libraries/coreMQTT-Agent/source/include
    ../../../../../libraries/coreMQTT-Agent/source/include/: core_mqtt_agent.h core_mqtt_agent_command_functions.h core_mqtt_agent_message_interface.h
  group libraries/coreHTTP/source
    ../../../../../libraries/coreHTTP/source/: core_http_client.c
  group libraries/coreHTTP/source/dependency/3rdparty/llhttp/src
    ../../../../../libraries/coreHTTP/source/dependency/3rdparty/llhttp/src/: api.c llhttp.c http.c
  group libraries/coreHTTP/source/dependency/3rdparty/llhttp/include
    ../../../../../libraries/coreHTTP/source/dependency/3rdparty/llhttp/include/: llhttp.h
  group libraries/coreHTTP/source/include
    ../../../../../libraries/coreHTTP/source/include/: core_http_client.h core_http_client_private.h core_http_config_defaults.h
  group libraries/coreHTTP/source/interface
    ../../../../../libraries/coreHTTP/source/interface/: transport_interface.h
  group libraries/coreJSON/source
    ../../../../../libraries/coreJSON/source/: core_json.c
  group libraries/coreJSON/source/include
    ../../../../../libraries/coreJSON/source/include/: core_json.h
  group libraries/device_shadow_for_aws/source
    ../../../../../libraries/device_shadow_for_aws/source/: shadow.c
  group libraries/device_shadow_for_aws/source/include
    ../../../../../libraries/device_shadow_for_aws/source/include/: shadow.h shadow_config_defaults.h
  group libraries/device_defender_for_aws/source
    ../../../../../libraries/device_defender_for_aws/source/: defender.c
  group libraries/device_defender_for_aws/source/include
    ../../../../../libraries/device_defender_for_aws/source/include/: defender.h defender_config_defaults.h
  group libraries/jobs_for_aws/source
    ../../../../../libraries/jobs_for_aws/source/: jobs.c
  group libraries/jobs_for_aws/source/include
    ../../../../../libraries/jobs_for_aws/source/include/: jobs.h
  group demos/dev_mode_key_provisioning/src
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group demos/dev_mode_key_provisioning/include
    ../../../../../demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
  group demos/common/pkcs11_helpers
    ../../../../../demos/common/pkcs11_helpers/: pkcs11_helpers.c
  group demos/common/http_demo_helpers
    ../../../../../demos/common/http_demo_helpers/: http_demo_utils.c
  group demos/common/mqtt_demo_helpers
    ../../../../../demos/common/mqtt_demo_helpers/: mqtt_demo_helpers.c
  group demos/include
    ../../../../../demos/include/: aws_iot_metrics.h
