# IAR project spifi_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54018 NXP LPC54018
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MBEDTLS_CONFIG_FILE="aws_mbedtls_config.h"; CONFIG_MEDTLS_USE_AFR_MEMORY; DEBUG; XIP_IMAGE; CPU_LPC54018; SDK_DEBUGCONSOLE=1; USB_STACK_BM; USB_STACK_USE_DEDICATED_RAM=1; CPU_LPC54018JET180=1; USE_RTOS=1; FSL_RTOS_FREE_RTOS; A_LITTLE_ENDIAN; __little_endian__=1; CBOR_PRETTY_PRINT=0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\..\vendors\nxp\boards\lpc54018iotmodule\aws_demos\config_files; ..\..\..\..\..\vendors\nxp\boards\lpc54018iotmodule\aws_demos\application_code\nxp_code; ..\..\..\..\..\vendors\nxp\LPC54018; ..\..\..\..\..\vendors\nxp\LPC54018\drivers; ..\..\..\..\..\vendors\nxp\LPC54018\utilities; ..\..\..\..\..\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\libraries\3rdparty\mbedtls\include; ..\..\..\..\..\libraries\3rdparty\mbedtls\library; ..\..\..\..\..\libraries\3rdparty\mbedtls_utils; ..\..\..\..\..\libraries\3rdparty\mbedtls_config; ..\..\..\..\..\libraries\3rdparty\jsmn; ..\..\..\..\..\libraries\3rdparty\pkcs11; ..\..\..\..\..\libraries\abstractions\pkcs11\corePKCS11\source\portable\mbedtls\include; ..\..\..\..\..\libraries\3rdparty\tinycbor; ..\..\..\..\..\vendors\nxp\LPC54018\utilities\log; ..\..\..\..\..\vendors\nxp\LPC54018\utilities\io; ..\..\..\..\..\vendors\nxp\LPC54018\utilities\str; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos\gt202; ..\..\..\..\..\vendors\nxp\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/port/env/freertos; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/include; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/include/AR6002; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/include/AR6002/hw2.0/hw; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/include/AR6002/hw4.0/hw; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/custom_src/stack_custom; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/custom_src/include; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/common_src/include; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/common_src/stack_common; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/common_src/hcd; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/common_src/wmi; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/port; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/wifi_qca/port/drivers/flexcomm_freertos; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/usb/device; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/usb/include; ..\..\..\..\..\vendors\nxp\LPC54018\middleware/usb/osa; ..\..\..\..\..\vendors\nxp\LPC54018\bootloader
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; XIP_IMAGE; MXL12835F; IMG_BAUDRATE=96000000
  AARM.AUserIncludes: ..\..\..\..\..\vendors\nxp\boards\lpc54018iotmodule\aws_demos\config_files
  OBJCOPY.OOCOutputFile: spifi_bootloader.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: XIP_IMAGE=1
  ILINK.IlinkIcfFile: ../../../../../vendors/nxp/LPC54018/iar/LPC54018_spifi_flash_data.icf
  ILINK.IlinkAdditionalLibs: ../../../../../vendors/nxp/LPC54018/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application_code
    ../../../../../vendors/nxp/boards/lpc54018iotmodule/bootloader/: main.c
  group application_code/nxp_code
    ../../../../../vendors/nxp/boards/lpc54018iotmodule/aws_demos/application_code/nxp_code/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group libraries/3rdparty/mbedtls/include
    ../../../../../libraries/3rdparty/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group libraries/3rdparty/mbedtls/src
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c constant_time_internal.h constant_time_invasive.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_invasive.h entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_error.c
  group libraries/3rdparty/vendors/nxp/LPC54018/bootloader
    ../../../../../vendors/nxp/LPC54018/bootloader/: spifi_boot.c spifi_boot.h
  group libraries/3rdparty/vendors/nxp/LPC54018/drivers
    ../../../../../vendors/nxp/LPC54018/drivers/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_emc.c fsl_emc.h fsl_enet.c fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2s.c fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_pint.c fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spi.c fsl_spi_dma.c fsl_spifi.c fsl_spifi.h fsl_usart.c fsl_usart.h fsl_wwdt.c fsl_wwdt.h mflash_drv.c mflash_drv.h mflash_file.c mflash_file.h
    ../../../../../vendors/nxp/LPC54018/utilities/log/: fsl_log.c fsl_log.h
  group libraries/3rdparty/vendors/nxp/LPC54018/middleware/osa
    ../../../../../vendors/nxp/LPC54018/middleware/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group libraries/3rdparty/vendors/nxp/LPC54018/middleware/usb/device/include
    ../../../../../vendors/nxp/LPC54018/middleware/usb/device/: usb_device.h
  group libraries/3rdparty/vendors/nxp/LPC54018/middleware/usb/device/src
    ../../../../../vendors/nxp/LPC54018/middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group libraries/3rdparty/vendors/nxp/LPC54018/middleware/usb/device/src/lpcip3511
    ../../../../../vendors/nxp/LPC54018/middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group libraries/3rdparty/vendors/nxp/LPC54018/middleware/usb/include
    ../../../../../vendors/nxp/LPC54018/middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group libraries/3rdparty/vendors/nxp/LPC54018/middleware/utilities
    ../../../../../vendors/nxp/LPC54018/utilities/: fsl_assert.c fsl_debug_console_conf.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h
    ../../../../../vendors/nxp/LPC54018/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../vendors/nxp/LPC54018/utilities/str/: fsl_str.c fsl_str.h
  group libraries/3rdparty/vendors/nxp/LPC54018/startup
    ../../../../../vendors/nxp/LPC54018/iar/: startup_LPC54018.s
    ../../../../../vendors/nxp/LPC54018/: system_LPC54018.c system_LPC54018.h
  group libraries/3rdparty/vendors/nxp/LPC54018/utilities
    ../../../../../vendors/nxp/LPC54018/utilities/: fsl_debug_console.c fsl_debug_console.h
